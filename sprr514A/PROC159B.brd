# Allegro board PROC159B.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
ICSSM_MII0_RXD1: length 17.3
  TOP w0.147: v1(65.26,57.39) 64.51,57.39 64.36,57.25 64.36,57.04 64.53,56.87 65.65,56.87 65.91,56.62 65.91,56.31 65.66,56.06 65.66,55.28 66.33,54.6 68.72,54.6 68.96,54.85 68.96,55.3 69.24,55.58 71.34,55.58 71.65,55.88 74.72,55.88 74.78,55.94 U87.39
  BOTTOM w0.147: v1(65.26,57.39) U82.3
ICSSM_MII0_RXD1_ADD: length 27.7
  TOP w0.147: v1(75.34,72.64) 75.8,73.1 76.49,73.1 76.52,73.07 76.53,73.07 76.94,72.66 R534.1
  L03_SIG1 w0.091: v1(75.34,72.64) 70.87,68.17 70.87,67.62 67.45,64.2 67.45,56.62 68.04,56.03 69.51,56.03 v1(70.43,55.11)
  BOTTOM w0.147: U82.40 68.96,54.88 69.22,54.63 69.96,54.63 v1(70.43,55.11)
ICSSM_MII0_RXD1_ON: length 57.5
  TOP w0.147: v1(85.54,81.12) 85.03,81.62 84.29,81.62 83.79,81.12 R477.1
  L03_SIG1 w0.091: v1(69.46,55.11) 69,55.57 68.22,55.57 68.01,55.37 68.01,54.65 67.86,54.5 66.13,54.5 64.34,56.29 64.34,57.5 64.7,57.86 65.47,57.86 65.79,57.54 65.79,56.59 65.95,56.42 66.67,56.42 66.9,56.65 66.9,59.63 66.79,59.74 65.8,59.74 65.69,59.84 65.69,60 65.8,60.1 66.79,60.1 66.9,60.21 66.9,60.91 66.79,61.01 66.55,61.01 66.44,61.12 66.44,61.27 66.55,61.38 66.79,61.38 66.9,61.49 66.9,65.25 74.89,73.24 74.89,73.95 75.07,74.13 78.63,74.13 79.5,75 79.5,81.94 80.24,82.68 83.26,82.68 84.36,81.59 85.06,81.59 v1(85.54,81.12)
  BOTTOM w0.147: U82.39 v1(69.46,55.11)
ICSSM_MII0_RXD2: length 16.8
  TOP w0.147: U87.38 71.99,56.39 71.55,56.84 71.16,56.84 70.86,56.54 70.86,56.11 70.67,55.93 69.18,55.93 68.85,55.6 68.59,55.6 68.46,55.73 68.46,56.23 68.61,56.37 69.87,56.37 70.02,56.52 70.02,57.1 69.83,57.3 67.52,57.3 67.32,57.09 67.32,56.71 67.15,56.55 66.46,56.55 65.85,57.16 65.85,57.57 v1(66.18,57.89)
  BOTTOM w0.147: U82.4 v1(66.18,57.89)
ICSSM_MII0_RXD2_ADD: length 28
  TOP w0.147: v1(75.34,71.65) 75.8,72.11 76.49,72.11 76.52,72.08 76.53,72.08 76.94,71.67 R535.1
  L08_SIG2 w0.091: v1(75.34,71.65) 71.37,71.65 70.65,72.37 69.21,72.37 68.63,71.79 68.63,65.52 70,64.15 70,57.98 71.04,56.94 72.12,56.94 v1(72.17,56.89)
  BOTTOM w0.147: v1(72.17,56.89) U82.37
ICSSM_MII0_RXD2_ON: length 57.8
  TOP w0.147: R479.1 84.28,80.58 85.1,80.58 v1(85.42,80.26)
  L03_SIG1 w0.091: v1(85.42,80.26) 84.94,79.78 84.94,79.13 85.54,78.53 85.54,78.04 84.72,77.22 84.72,75.78 84.85,75.65 84.85,75.65 85.66,74.84 85.66,74.49 86.52,73.63 86.52,71.17 86.09,70.74 86.09,68.55 85.85,68.31 84.29,68.31 84.1,68.12 84.1,67.62 83.95,67.47 82.39,67.47 82.01,67.09 80.99,67.09 80,68.09 80,70.23 79.06,71.17 78.44,71.17 78.21,70.95 77.88,70.95 76.07,69.14 74.64,69.14 69.99,64.49 69.99,56.31 70.86,55.45 70.86,54.79 70.42,54.36 69.1,54.36 68.55,53.81 68.55,53.37 68.78,53.14 69.28,53.14 69.74,53.6 70.8,53.6 71.53,54.34 71.53,56.06 v1(71.32,56.27)
  BOTTOM w0.147: U82.38 71.2,56.39 v1(71.32,56.27)
ICSSM_MII0_RXD3: length 16.6
  TOP w0.147: U87.36 73.34,57.39 73.21,57.26 73.21,56.83 73.08,56.7 72.9,56.7 72.77,56.83 72.77,57.26 72.64,57.39 71.99,57.39 71.48,57.9 70.94,57.9 70.79,57.75 70.79,56.91 70.67,56.79 70.46,56.79 70.32,56.94 70.32,57.51 70.17,57.65 67.42,57.65 66.74,56.97 66.46,56.97 66.28,57.15 66.28,57.32 66.92,57.95 66.92,58.23 66.76,58.39 v1(65.26,58.39)
  BOTTOM w0.147: v1(65.26,58.39) U82.5
ICSSM_MII0_RXD3_ADD: length 27.5
  TOP w0.147: v1(75.34,70.66) 75.8,71.11 76.49,71.11 76.52,71.09 76.53,71.09 76.94,70.68 R536.1
  L08_SIG2 w0.091: v1(75.34,70.66) 74.74,71.27 74.25,71.27 74.12,71.13 74.12,70.99 73.98,70.86 73.79,70.86 73.66,70.99 73.66,71.13 73.53,71.27 71.37,71.27 70.54,72.1 69.33,72.1 68.91,71.68 68.91,65.63 70.28,64.26 70.28,58.24 70.63,57.89 v1(72.17,57.89)
  BOTTOM w0.147: v1(72.17,57.89) U82.35
ICSSM_MII0_RXD3_ON: length 58.2
  TOP w0.147: R480.1 85.23,78.27 85.43,78.46 v1(85.43,79.32)
  L03_SIG1 w0.091: v1(71.25,57.39) 70.99,57.66 70.73,57.66 70.27,58.12 70.27,64.38 74.03,68.14 75.85,68.14 77.06,69.35 77.06,69.73 77.46,70.14 79.17,70.14 79.72,69.59 79.72,67.97 81.13,66.57 82.12,66.57 82.31,66.39 85.38,66.39 85.52,66.25 85.52,66.03 85.38,65.89 82.61,65.89 82.49,65.77 82.49,65.55 82.61,65.44 85.57,65.44 85.93,65.8 85.93,66.51 85.5,66.94 84.56,66.94 84.46,67.05 84.46,67.2 84.56,67.31 85.82,67.31 85.93,67.41 85.93,67.57 85.82,67.67 84.56,67.67 84.46,67.78 84.46,67.93 84.56,68.04 85.96,68.04 86.36,68.44 86.36,70.62 86.79,71.06 86.79,73.75 85.93,74.61 85.93,74.96 85,75.9 85,77.09 85.93,78.03 85.93,78.82 v1(85.43,79.32)
  BOTTOM w0.147: U82.36 v1(71.25,57.39)
ICSSM_MII0_RXDV: length 17.3
  TOP w0.147: v1(66.18,58.89) 66.18,59.31 66.31,59.45 67.29,59.45 67.42,59.31 67.42,59.19 67.3,59.07 67.1,59.07 66.96,58.93 66.96,58.71 67.22,58.45 67.58,58.45 67.76,58.63 69.6,58.63 70.01,59.04 70.01,59.22 70.19,59.4 70.41,59.4 70.56,59.25 70.56,59.07 70.27,58.77 70.27,58.22 70.39,58.09 70.58,58.09 70.71,58.22 70.71,58.56 71.04,58.89 71.51,58.89 72.01,58.39 72.43,58.39 72.62,58.58 72.62,58.93 72.78,59.08 73.27,59.08 73.42,58.94 73.42,58.68 72.78,58.04 72.78,57.81 72.91,57.68 73.22,57.68 73.41,57.87 73.41,58.02 73.79,58.39 U87.34
  BOTTOM w0.147: U82.6 v1(66.18,58.89)
ICSSM_MII0_RXDV_ADD: length 27.9
  L08_SIG2 w0.091: v1(72.17,58.89) 70.98,58.89 70.55,59.32 70.55,64.38 69.18,65.74 69.18,70.81 69.64,71.26 70.78,71.26 71.91,70.14 75.91,70.14 76.38,69.67 v1(78.54,69.67)
  BOTTOM w0.147: v1(78.54,69.67) 78.16,69.21 77.33,69.21 76.88,69.66 R537.1 ; v1(72.17,58.89) U82.33
ICSSM_MII0_RXDV_ON: length 57.8
  TOP w0.147: R481.1 v1(97.63,94.93)
  L08_SIG2 w0.091: v1(97.63,94.93) 98.67,93.9 98.67,90.09 97.71,89.12 97.71,83.8 95.88,81.98 94.98,81.98 94.06,81.05 90.24,81.05 86.83,77.65 86.83,76.22 85.9,75.29 85.19,75.29 84.74,75.74 84.42,75.74 83.26,74.58 83.26,71.71 81.51,69.96 81.51,63.2 80.41,62.11 80.41,61.74 79.46,60.78 79.46,60.4 77.72,58.67 75.21,58.67 74.94,58.39 v1(71.25,58.39)
  BOTTOM w0.147: U82.34 v1(71.25,58.39)
ICSSM_MII0_RXER: length 16.6
  TOP w0.147: v1(64.5,59.39) 63.55,59.39 63.35,59.2 63.35,58.77 63.53,58.6 64.71,58.6 65.87,59.76 70.98,59.76 71.06,59.85 71.5,59.85 71.95,59.39 U87.32
  BOTTOM w0.147: U82.7 65.94,59.39 65.61,59.07 64.83,59.07 v1(64.5,59.39)
ICSSM_MII0_RXER_ADD: length 28
  L08_SIG2 w0.091: v1(78.54,68.68) 78.06,69.16 75.08,69.16 74.38,69.86 73.93,69.86 73.8,69.73 73.8,69.48 73.66,69.35 73.47,69.35 73.34,69.48 73.34,69.73 73.2,69.86 73.01,69.86 72.88,69.73 72.88,69.48 72.75,69.35 72.56,69.35 72.42,69.48 72.42,69.73 72.29,69.86 71.75,69.86 70.62,70.99 69.75,70.99 69.46,70.7 69.46,65.86 70.82,64.49 70.82,60.15 71.08,59.89 v1(72.17,59.89)
  BOTTOM w0.147: v1(78.54,68.68) 78.16,68.22 77.33,68.22 76.88,68.67 R538.1 ; v1(72.17,59.89) U82.31
ICSSM_MII0_RXER_ON: length 57.5
  TOP w0.147: R482.1 v1(97.63,93.94)
  L08_SIG2 w0.091: v1(97.63,93.94) 98.21,93.94 98.39,93.76 98.39,90.2 97.47,89.27 97.47,83.95 95.72,82.2 94.89,82.2 93.94,81.26 90.15,81.26 86.61,77.71 86.61,76.39 85.76,75.54 85.37,75.54 84.9,76 84.37,76 83,74.63 83,71.82 81.25,70.07 81.25,63.2 80.39,62.35 79.76,62.35 79.48,62.06 79.48,61.53 79.06,61.1 78.76,61.1 77.43,59.78 75.23,59.78 74.84,59.39 73.2,59.39 73.09,59.29 73.09,58.71 72.98,58.61 72.83,58.61 72.72,58.71 72.72,59.29 72.62,59.39 v1(71.25,59.39)
  BOTTOM w0.147: U82.32 v1(71.25,59.39)
ICSSM_MII0_RXLINK: length 16.6
  TOP w0.147: U87.27 72.77,61.89 72.61,62.06 72.61,62.27 72.73,62.39 73.3,62.39 73.44,62.54 73.44,62.8 72.64,63.61 72.64,64.72 72.3,65.06 71.38,65.06 71.09,64.77 71.09,64.51 71.21,64.38 71.56,64.38 71.69,64.25 71.69,64.07 71.56,63.94 71.21,63.94 71.09,63.81 71.09,62.99 70.93,62.84 70.4,62.84 69.66,62.09 67.33,62.09 67.13,61.89 v1(66.18,61.89)
  BOTTOM w0.147: U82.12 v1(66.18,61.89)
ICSSM_MII0_RXLINK_ADD: length 27.5
  L08_SIG2 w0.091: v1(71.25,62.39) 71.25,64.45 69.73,65.97 69.73,70.39 69.98,70.64 70.58,70.64 72.25,68.98 74.46,68.98 75.25,68.18 75.76,68.18 76.36,68.79 77.78,68.79 78.38,68.18 78.73,68.18 78.98,68.44 78.98,69.62 79.12,69.76 79.27,69.76 79.38,69.65 79.38,67.54 v1(78.54,66.7)
  BOTTOM w0.147: U82.26 v1(71.25,62.39) ; v1(78.54,66.7) 78.16,66.23 77.33,66.23 76.88,66.69 R540.1
ICSSM_MII0_RXLINK_ON: length 57.5
  TOP w0.147: R484.1 v1(97.63,91.96)
  L08_SIG2 w0.091: v1(72.17,61.89) 72.17,61.55 72.39,61.33 73.24,61.33 73.46,61.55 73.46,62.02 73.36,62.13 72.72,62.13 72.61,62.24 72.61,62.39 72.72,62.49 73.36,62.49 73.46,62.6 73.46,62.97 73.68,63.19 74.34,63.19 74.45,63.08 74.45,61.39 74.56,61.28 74.71,61.28 74.82,61.39 74.82,63.08 74.92,63.19 78.11,63.19 78.79,63.86 80.4,63.86 80.75,64.21 80.75,64.87 80.57,65.05 79.94,65.05 79.83,65.15 79.83,65.3 79.94,65.41 80.66,65.41 80.75,65.5 80.75,70.28 82.5,72.03 82.5,74.76 85.15,77.42 85.77,77.42 89.99,81.64 93.81,81.64 94.9,82.73 94.9,83.14 96.91,85.15 96.91,89.51 97.63,90.23 v1(97.63,91.96)
  BOTTOM w0.147: v1(72.17,61.89) U82.27
ICSSM_MII0_TXCLK: length 15.7
  TOP w0.147: U85.3 v1(94.14,98.84)
  BOTTOM w0.147: v1(94.14,98.84) 94.6,98.38 94.6,97.12 93.54,96.06 86.65,96.06 86.41,96.3 86.08,96.3 85.91,96.47 85.91,97.06 85.73,97.24 85.49,97.24 85.32,97.06 85.32,96.47 85.14,96.3 84.79,96.3 84.59,96.5 U88.39
ICSSM_MII0_TXCLK_ADD: length 52.6
  TOP w0.147: U85.40 v1(91.35,96.55)
  L08_SIG2 w0.091: v1(68.45,81.7) 68.91,82.16 70.09,82.16 70.98,81.27 70.98,79.97 70.37,79.36 70.37,76.31 71.58,75.1 75.75,75.1 76.01,74.84 76.01,74.41 78.33,72.09 79.04,72.09 80.47,73.52 80.47,78 82.26,79.79 82.26,80.76 83.18,81.67 83.18,83.16 85.18,85.16 85.18,91.78 85.82,92.43 85.82,92.91 86.23,93.32 87.54,93.32 90.77,96.55 v1(91.35,96.55)
  BOTTOM w0.147: v1(68.45,81.7) 67.98,82.16 67.98,83 68.44,83.45 R520.1
ICSSM_MII0_TXCLK_ON: length 31
  TOP w0.147: U85.39 90.85,96.04 91.1,95.79 93.07,95.79 93.31,96.02 93.31,96.8 93.46,96.95 93.76,96.95 93.89,96.82 93.89,96.14 94.02,96.01 94.52,96.01 95.85,97.34 95.85,98.11 96.12,98.37 96.84,98.37 97.13,98.66 97.13,99.17 96.9,99.4 96.09,99.4 95.85,99.64 95.85,100.15 96.1,100.4 96.68,100.4 96.92,100.4 97.41,100.89 97.41,103.05 97.62,103.25 97.62,104.68 97.77,104.83 98.14,104.83 98.29,104.68 98.29,103.2 97.98,102.89 97.98,100.79 97.59,100.4 97.59,99.68 97.86,99.41 100.01,99.41 100.22,99.2 100.22,98.72 99.95,98.45 98.47,98.45 98.32,98.6 R496.1
ICSSM_MII0_TXD0: length 16.1
  TOP w0.147: U85.4 94.55,99.34 v1(95.05,98.84)
  BOTTOM w0.147: U88.38 86.22,97.84 86.44,97.62 86.44,96.73 86.82,96.36 90.49,96.36 91.06,96.92 91.06,97.19 90.25,98 90.25,98.49 90.56,98.8 93.43,98.8 93.94,99.31 94.58,99.31 v1(95.05,98.84)
ICSSM_MII0_TXD0_ADD: length 52.3
  TOP w0.147: U85.37 88.92,98.34 88.65,98.07 88.38,98.07 88.38,98.07 v1(88.15,97.84)
  L08_SIG2 w0.091: v1(77.49,74.65) 78.03,74.12 78.45,74.12 79.86,75.52 79.86,78.17 81.72,80.03 81.72,84.56 82.09,84.93 82.09,87.42 80.72,88.79 80.72,89.92 81.13,90.33 81.65,90.33 81.91,90.08 81.91,88.82 82.13,88.6 82.38,88.6 82.55,88.77 82.55,91.39 82.85,91.68 84.69,91.68 85.38,92.37 85.38,92.93 86.05,93.6 87.43,93.6 90.82,96.99 92.54,96.99 92.8,96.73 92.8,95.8 93.08,95.51 93.77,95.51 94.57,96.31 94.57,96.98 94.25,97.3 93.94,97.3 93.34,97.9 93.34,98.1 92.65,98.8 90.57,98.8 89.61,97.84 v1(88.15,97.84)
  BOTTOM w0.147: R521.1 v1(77.49,74.65)
ICSSM_MII0_TXD0_ON: length 30.6
  TOP w0.147: U85.38 89.42,97.84 89.18,97.6 89.18,97.19 89.44,96.94 89.68,96.94 89.92,97.18 90.16,97.18 90.34,97.01 90.34,96.76 90.1,96.52 90.1,96.28 90.89,95.49 94.58,95.49 95.41,96.33 95.94,96.33 96.08,96.48 96.08,97.16 96.31,97.38 96.37,97.38 96.84,97.38 97.05,97.17 97.05,96.58 97.3,96.33 100.59,96.33 101.05,96.79 101.05,98.53 100.88,98.7 100.7,98.7 100.52,98.88 100.52,99.12 100.69,99.29 100.88,99.29 101.05,99.46 101.05,100.04 100.88,100.21 100.44,100.21 100.26,100.38 100.26,100.62 100.44,100.79 100.88,100.79 101.05,100.96 101.05,101.24 100.91,101.38 100,101.38 99.73,101.12 99.73,100.63 99.52,100.43 98.74,100.43 98.57,100.6 98.57,101.25 98.74,101.42 99.26,101.42 99.44,101.59 99.44,101.84 99.26,102.01 98.74,102.01 98.57,102.18 98.57,102.34 98.71,102.48 98.95,102.48 99.09,102.62 R497.1
ICSSM_MII0_TXD1: length 15.6
  TOP w0.147: U85.5 v1(94.14,99.84)
  BOTTOM w0.147: U88.36 86.55,98.84 86.86,98.52 86.86,98.18 87.03,98.01 87.43,98.01 87.6,97.84 87.6,97.59 87.43,97.42 87.03,97.42 86.86,97.25 86.86,96.99 87.2,96.65 90.37,96.65 90.61,96.9 90.61,97.22 89.96,97.88 89.96,98.73 90.32,99.1 92.94,99.1 93.68,99.84 v1(94.14,99.84)
ICSSM_MII0_TXD1_ADD: length 52.3
  TOP w0.147: v1(88.15,98.84) 88.35,99.04 88.56,99.04 88.86,99.34 U85.35
  L08_SIG2 w0.091: v1(88.15,98.84) 89.64,98.84 89.78,98.69 89.78,98.42 89.62,98.26 87.89,98.26 87.67,98.04 87.67,97.56 87.89,97.35 89.76,97.35 90.2,97.78 93.03,97.78 93.78,97.03 94.14,97.03 94.3,96.87 94.3,96.43 93.66,95.79 93.4,95.79 93.07,96.12 93.07,96.84 92.65,97.26 90.58,97.26 87.31,93.99 85.78,93.99 84.5,92.7 82.77,92.7 82.28,92.21 82.28,90.92 81.96,90.61 81.02,90.61 80.44,90.03 80.44,88.68 81.82,87.3 81.82,85.05 81.45,84.67 81.45,80.15 79.58,78.28 79.58,75.66 79.06,75.13 78.09,75.13 v1(77.55,75.68)
  BOTTOM w0.147: R522.1 77.49,75.68 77.49,75.68 v1(77.55,75.68)
ICSSM_MII0_TXD1_ON: length 30.7
  TOP w0.147: R498.1 99.09,104.01 99.09,103.69 99.28,103.51 100.81,103.51 101.35,102.98 101.35,102.57 101.17,102.39 100.26,102.39 100.09,102.22 100.09,101.98 100.26,101.8 101.17,101.8 101.35,101.63 101.35,96.67 100.71,96.03 95.53,96.03 94.7,95.2 89.97,95.2 89.68,95.49 89.68,95.73 89.76,95.8 89.76,96.05 89.58,96.22 89.34,96.22 89.26,96.15 89.02,96.15 88.85,96.32 88.85,96.56 88.92,96.64 88.92,96.88 88.75,97.05 88.51,97.05 88.43,96.98 88.19,96.98 87.63,97.54 87.63,98.06 87.95,98.38 88.51,98.38 88.96,98.84 U85.36
ICSSM_MII0_TXD2: length 15.7
  TOP w0.147: v1(95.05,99.84) 94.55,100.34 U85.6
  BOTTOM w0.147: v1(95.05,99.84) 94.55,100.34 93.4,100.34 93.07,100 90.46,100 89.6,99.14 89.6,97.42 89.44,97.26 88.82,97.26 88.67,97.41 88.67,98.02 88.37,98.32 87.69,98.32 87.12,98.89 87.12,99.5 86.79,99.84 U88.34
ICSSM_MII0_TXD2_ADD: length 52.3
  TOP w0.147: U85.33 88.65,100.34 v1(88.15,99.84)
  L08_SIG2 w0.091: v1(77.55,76.67) 77.71,76.67 78.15,76.22 78.65,76.22 79.31,76.88 79.31,78.4 80.06,79.14 80.06,79.3 79.93,79.43 79.93,79.58 80.03,79.68 80.19,79.68 80.31,79.55 80.47,79.55 80.57,79.66 80.57,79.81 80.44,79.94 80.44,80.09 80.55,80.2 80.7,80.2 80.83,80.07 80.98,80.07 81.17,80.26 81.17,80.78 81.06,80.89 80.33,80.89 80.22,80.99 80.22,81.15 80.33,81.25 81.06,81.25 81.17,81.36 81.17,81.51 81.06,81.62 80.33,81.62 80.22,81.73 80.22,81.88 80.33,81.98 81.06,81.98 81.17,82.09 81.17,82.24 81.06,82.35 80.33,82.35 80.22,82.46 80.22,82.61 80.33,82.72 81.06,82.72 81.17,82.82 81.17,82.97 81.06,83.08 80.33,83.08 80.22,83.19 80.22,83.34 80.33,83.45 81.06,83.45 81.17,83.55 81.17,83.71 81.06,83.81 80.33,83.81 80.22,83.92 80.22,84.07 80.33,84.18 81.06,84.18 81.17,84.29 81.17,84.44 81.06,84.54 80.33,84.54 80.22,84.65 80.22,84.8 80.33,84.91 81.06,84.91 81.17,85.02 81.17,85.17 81.06,85.28 80.33,85.28 80.22,85.38 80.22,85.53 80.33,85.64 81.06,85.64 81.17,85.75 81.17,86.19 79.91,87.45 79.91,89.89 80.91,90.88 81.85,90.88 82,91.04 82,92.33 82.65,92.98 84.38,92.98 85.67,94.26 87.12,94.26 87.53,94.67 87.53,94.82 87.32,95.03 87.32,95.18 87.43,95.28 87.58,95.28 87.78,95.08 87.94,95.08 88.04,95.19 88.04,95.34 87.84,95.54 87.84,95.69 87.94,95.8 88.1,95.8 88.3,95.6 88.45,95.6 88.56,95.7 88.56,95.85 88.35,96.06 88.35,96.21 88.46,96.32 88.61,96.32 88.82,96.11 88.97,96.11 89.43,96.57 89.43,96.87 89.23,97.07 87.78,97.07 87.4,97.45 87.4,99.08 v1(88.15,99.84)
  BOTTOM w0.147: R523.1 77.49,76.67 77.49,76.67 v1(77.55,76.67)
ICSSM_MII0_TXD2_ON: length 31
  TOP w0.147: U85.34 88.81,99.84 88.31,99.33 87.7,99.33 87.31,98.94 87.31,97.35 89.75,94.9 94.82,94.9 95.66,95.74 100.83,95.74 101.64,96.55 101.64,103.64 100.77,104.51 99.27,104.51 99.09,104.69 R499.1
ICSSM_MII0_TXD3: length 15.7
  TOP w0.147: U85.7 v1(94.14,100.84)
  BOTTOM w0.147: U88.32 86.63,100.84 86.88,100.58 86.88,100.32 87.87,99.33 88.44,99.33 88.67,99.1 88.67,98.65 88.84,98.48 89.16,98.48 89.3,98.63 89.3,99.26 89.56,99.52 89.56,99.77 89.3,100.03 89.3,100.27 89.48,100.44 89.72,100.44 89.98,100.18 90.23,100.18 90.37,100.33 92.7,100.33 93.2,100.84 93.2,101.36 93.35,101.51 94.29,101.51 94.78,101.03 94.78,100.8 94.62,100.63 94.34,100.63 v1(94.14,100.84)
ICSSM_MII0_TXD3_ADD: length 52.5
  TOP w0.147: v1(88.15,100.84) 88.65,101.34 U85.31
  L08_SIG2 w0.091: v1(78.26,77.66) 79.03,78.43 79.03,78.68 79.44,79.08 79.44,79.88 79.89,80.33 79.89,80.85 79.78,80.96 79.28,80.96 79.17,81.06 79.17,81.22 79.28,81.32 79.78,81.32 79.89,81.43 79.89,81.58 79.78,81.69 79.28,81.69 79.17,81.8 79.17,81.95 79.28,82.05 79.78,82.05 79.89,82.16 79.89,82.31 79.78,82.42 79.28,82.42 79.17,82.53 79.17,82.68 79.28,82.79 79.78,82.79 79.89,82.89 79.89,83.04 79.78,83.15 79.28,83.15 79.17,83.26 79.17,83.41 79.28,83.52 79.78,83.52 79.89,83.62 79.89,83.78 79.78,83.88 79.28,83.88 79.17,83.99 79.17,84.14 79.28,84.25 79.78,84.25 79.89,84.36 79.89,84.51 79.78,84.61 79.28,84.61 79.17,84.72 79.17,84.87 79.28,84.98 79.78,84.98 79.89,85.09 79.89,85.24 79.78,85.35 79.28,85.35 79.17,85.45 79.17,85.6 79.28,85.71 79.78,85.71 79.89,85.82 79.89,85.97 79.78,86.08 79.28,86.08 79.17,86.18 79.17,86.34 79.28,86.44 79.78,86.44 79.89,86.55 79.89,87.09 79.8,87.18 79.64,87.34 79.64,87.7 79.53,87.81 79.15,87.81 79.04,87.92 79.04,88.07 79.15,88.18 79.53,88.18 79.64,88.28 79.64,88.43 79.53,88.54 79.15,88.54 79.04,88.65 79.04,88.8 79.15,88.91 79.53,88.91 79.64,89.01 79.64,89.17 79.53,89.27 79.15,89.27 79.04,89.38 79.04,89.53 79.15,89.64 79.53,89.64 79.64,89.75 79.64,90.05 79.53,90.15 79.22,90.15 79.12,90.26 79.12,90.41 79.22,90.52 79.53,90.52 79.64,90.63 79.64,90.78 79.53,90.88 79.22,90.88 79.12,90.99 79.12,91.14 79.22,91.25 79.53,91.25 79.64,91.36 79.64,91.73 79.81,91.9 79.96,91.9 80.09,91.76 80.09,90.96 80.19,90.86 80.4,90.86 80.52,90.98 80.52,92.23 80.69,92.4 80.92,92.4 81.06,92.25 81.06,91.33 81.23,91.16 81.53,91.16 81.73,91.36 81.73,92.44 82.54,93.25 84.27,93.25 85.55,94.54 86.66,94.54 86.91,94.8 86.91,95.32 86.7,95.54 86.7,96.04 86.92,96.26 87.95,96.26 88.08,96.39 88.08,96.58 87.96,96.7 87.56,96.7 87.12,97.13 87.12,99.81 v1(88.15,100.84)
  BOTTOM w0.147: R524.1 78.25,77.67 v1(78.26,77.66)
ICSSM_MII0_TXD3_ON: length 30.9
  TOP w0.147: U85.32 v1(89.06,100.84) ; R500.1 v1(98.31,106)
  BOTTOM w0.147: v1(89.06,100.84) 89.54,101.31 92.61,101.31 93.85,102.55 94.42,102.55 95.1,101.87 102.07,101.87 102.85,102.65 102.85,103.42 102.67,103.59 101.53,103.59 101.35,103.77 101.35,104.01 101.53,104.18 102.67,104.18 102.85,104.36 102.85,104.6 102.67,104.77 101.53,104.77 101.35,104.94 101.35,105.19 101.53,105.36 102.67,105.36 102.85,105.53 102.85,106.16 102.1,106.91 98.77,106.91 98.31,106.45 v1(98.31,106)
ICSSM_MII0_TXEN: length 16
  TOP w0.147: v1(95.05,97.84) 94.55,98.34 U85.2
  BOTTOM w0.147: U88.41 83.59,96.34 83.92,96.01 86.29,96.01 86.55,95.75 93.68,95.75 95.05,97.12 v1(95.05,97.84)
ICSSM_MII0_TXEN_ADD: length 52.5
  TOP w0.147: U85.42 v1(92.35,96.55)
  L08_SIG2 w0.091: v1(92.35,96.55) 91.4,95.6 90.4,95.6 87.12,92.31 86.17,92.31 85.36,91.5 85.36,85.08 83.36,83.08 83.36,81.6 82.44,80.68 82.44,79.41 80.74,77.7 80.74,73.29 78.76,71.31 78.46,71.31 78.33,71.18 77.96,71.18 76.71,72.42 76.71,73.06 75.63,74.13 74.68,74.13 74.24,73.7 72.27,73.7 69.76,76.21 69.76,81.38 v1(69.44,81.7)
  BOTTOM w0.147: v1(69.44,81.7) 68.98,82.16 68.98,83 69.43,83.45 R519.1
ICSSM_MII0_TXEN_ON: length 30.6
  TOP w0.147: R495.1 98.06,99.9 97.88,100.07 97.88,100.28 98.27,100.67 98.27,102.77 98.58,103.08 98.58,105.33 98.76,105.51 101.51,105.51 101.83,105.83 101.83,106.39 101.46,106.76 98.09,106.76 97.62,106.29 97.62,105.8 97.32,105.5 97.32,103.37 97.12,103.17 97.12,101.02 96.8,100.69 95.8,100.69 95.54,100.43 95.54,97.64 95.19,97.29 93.19,97.29 92.98,97.08 92.98,96.43 92.63,96.08 92.08,96.08 91.85,96.31 U85.41
ICSSM_MII1_COL: length 24
  TOP w0.147: U84.4 94.55,86.35 v1(95.05,85.85)
  BOTTOM w0.147: v1(95.05,85.85) 95.05,86.44 94.6,86.89 94.6,87.58 95.55,88.53 95.55,93.87 94.7,94.73 92.91,94.73 92.64,94.45 92.64,93.72 92.05,93.13 90.69,93.13 90.15,93.67 87.44,93.67 87.2,93.43 87.2,92.52 86.83,92.15 86.83,91.65 86.53,91.35 U89.25
ICSSM_MII1_COL_ADD: length 47.4
  TOP w0.147: R509.1 v1(71.42,82.81) ; U84.38 v1(89.06,84.85)
  L08_SIG2 w0.091: v1(71.42,82.81) 70.53,83.7 68.42,83.7 67.82,83.1 67.82,81.26 69.02,80.06 69.02,74.8 71.64,72.18 75.54,72.18 75.77,71.95 75.77,71.42 76.07,71.12 76.54,71.12 77.43,70.24 78.86,70.24 81.28,72.66 81.28,77.3 82.96,78.98 83.5,78.98 84.05,78.43 85.16,78.43 86.39,79.66 86.39,81.91 88.44,83.96 88.44,84.23 v1(89.06,84.85)
ICSSM_MII1_COL_ON: length 23.4
  TOP w0.147: U84.37 88.84,85.35 88.56,85.07 88.56,84.35 v1(89.06,83.85)
  L08_SIG2 w0.091: v1(96.56,96.93) 94.6,94.97 90.92,94.97 90.06,94.1 90.06,88.27 89.5,87.71 89.5,84.28 v1(89.06,83.85)
  BOTTOM w0.147: R501.1 98.31,96.93 97.81,97.43 97.07,97.43 v1(96.56,96.93)
ICSSM_MII1_CRS: length 22.2
  TOP w0.147: v1(95.05,87.23) 94.67,86.85 U84.5
  BOTTOM w0.147: v1(95.05,87.23) 95.84,88.02 95.84,94 94.82,95.02 92.79,95.02 92.34,94.58 92.34,93.85 91.93,93.43 90.81,93.43 90.27,93.97 87.32,93.97 86.9,93.55 86.9,92.65 86.6,92.35 U89.23
ICSSM_MII1_CRS_ADD: length 45.6
  TOP w0.147: U84.36 v1(89.06,85.85) ; R510.1 v1(70.43,82.81)
  L08_SIG2 w0.091: v1(70.43,82.81) 69.88,83.36 68.36,83.36 68.01,83.01 68.01,81.44 69.29,80.16 69.29,74.91 71.08,73.12 75.51,73.12 75.85,72.78 75.85,72.46 76.1,72.21 76.35,72.21 77.75,70.81 78.22,70.81 78.51,71.1 78.96,71.1 81.03,73.17 81.03,77.42 82.87,79.26 83.62,79.26 84.22,78.67 84.68,78.67 84.96,78.95 84.96,79.51 85.21,79.76 85.61,79.76 86.06,80.22 86.06,82.06 87.68,83.67 87.68,84.47 v1(89.06,85.85)
ICSSM_MII1_CRS_ON: length 19.4
  TOP w0.147: U84.35 89.21,86.35 89.06,86.49 v1(89.06,86.85)
  L08_SIG2 w0.091: v1(89.06,86.85) 89.06,87.75 89.79,88.47 89.79,94.22 89.97,94.4 90.81,95.24 93.88,95.24 v1(96.56,97.92)
  BOTTOM w0.147: R502.1 98.31,97.92 97.81,98.42 97.07,98.42 v1(96.56,97.92)
ICSSM_MII1_RXCLK: length 21.4
  TOP w0.147: v1(87.29,89.85) 88.07,89.07 88.07,88.8 88.2,88.67 88.42,88.67 88.55,88.54 88.55,88.35 88.42,88.22 88.2,88.22 88.07,88.1 88.07,87.91 88.2,87.78 88.42,87.78 88.55,87.65 88.55,87.47 88.42,87.34 88.2,87.34 88.07,87.21 88.07,87.03 88.2,86.9 88.42,86.9 88.55,86.77 88.55,86.59 88.42,86.46 88.2,86.46 88.07,86.33 88.07,86.14 88.2,86.02 88.42,86.02 88.55,85.89 88.55,85.7 88.42,85.57 88.2,85.57 88.07,85.44 88.07,84.07 88.93,83.21 89.13,83.21 89.66,82.68 90.02,82.68 90.15,82.81 90.15,82.89 90.28,83.02 90.47,83.02 90.6,82.89 90.6,82.81 90.73,82.68 90.91,82.68 91.04,82.81 91.04,82.89 91.17,83.02 91.35,83.02 91.48,82.89 91.48,82.81 91.61,82.68 93.23,82.68 94.61,84.07 94.61,84.89 94.16,85.35 U84.2
  BOTTOM w0.147: U89.29 86.79,89.35 v1(87.29,89.85)
ICSSM_MII1_RXCLK_ADD: length 46.1
  TOP w0.147: U84.41 91.85,83.32 92.15,83.01 92.81,83.01 v1(93.35,83.56) ; R531.1 v1(77.6,67.69)
  L08_SIG2 w0.091: v1(77.6,67.69) 77.11,67.2 77.11,66.34 77.56,65.88 79,65.88 79.95,66.83 79.95,70.58 81.76,72.39 81.76,74.85 84.91,77.99 85.41,77.99 89.68,82.26 91.08,82.26 91.29,82.46 91.29,82.8 90.83,83.26 90.83,83.81 91.06,84.03 92.26,84.03 93.51,85.28 93.51,89.64 93.6,89.73 93.86,89.73 93.95,89.64 93.95,85.18 93.35,84.58 v1(93.35,83.56)
ICSSM_MII1_RXCLK_ON: length 17.7
  TOP w0.147: U84.42 v1(92.35,83.56)
  L08_SIG2 w0.091: v1(96.39,92.95) 96.11,93.23 95.89,93.23 95.57,92.92 95.57,90.18 95.26,89.87 94.81,89.87 94.23,89.29 94.23,85.05 93.63,84.45 93.63,84.11 93.78,83.95 93.78,83.31 93.24,82.77 92.35,82.77 92.1,83.02 92.1,83.31 v1(92.35,83.56)
  BOTTOM w0.147: v1(96.39,92.95) 96.85,92.95 97.35,93.46 97.89,93.46 98.4,92.95 R491.1
ICSSM_MII1_RXD0: length 21.3
  TOP w0.147: U84.11 94.55,89.85 v1(95.05,90.35)
  BOTTOM w0.147: v1(95.05,90.35) 95.05,88.77 94.25,87.96 94.25,86.18 93.88,85.81 90.47,85.81 90.28,85.62 90.28,84.25 89.41,83.38 88.56,83.38 88.43,83.51 88.43,83.84 88.3,83.97 88.11,83.97 87.98,83.84 87.98,83.51 87.85,83.38 87.43,83.38 87.06,83.01 83.89,83.01 83.59,83.3 U89.41
ICSSM_MII1_RXD0_ADD: length 46.3
  TOP w0.147: U84.29 88.65,89.35 87.89,90.1 87.89,91.05 87.44,91.5 87.44,93.54 87.09,93.89 86.13,93.89 85.84,93.6 85.84,90.76 85.67,90.59 85.42,90.59 85.25,90.76 85.25,93.28 85.08,93.45 83.04,93.45 81.42,95.07 v1(81.42,96.02)
  BOTTOM w0.147: v1(81.42,96.02) 81.42,94.97 76.85,90.4 76.85,84.63 78.55,82.93 78.55,79.03 78.99,78.58 78.99,74.64 78.45,74.1 77.07,74.1 76.94,73.97 R525.1
ICSSM_MII1_RXD0_ON: length 17.7
  TOP w0.147: U84.28 v1(89.06,89.85)
  L08_SIG2 w0.091: v1(89.06,89.85) 88.27,89.85 88.06,89.64 88.06,89.31 88.17,89.21 88.51,89.21 88.62,89.1 88.62,88.95 88.51,88.84 88.17,88.84 88.06,88.73 88.06,87.82 87.96,87.72 87,87.72 86.9,87.61 86.9,87.46 87,87.35 87.96,87.35 88.06,87.24 88.06,87.09 87.96,86.99 87,86.99 86.9,86.88 86.9,86.73 87,86.62 87.96,86.62 88.06,86.51 88.06,86.37 87.45,85.75 87.3,85.75 87.01,86.03 86.86,86.03 86.75,85.93 86.75,85.77 87.04,85.49 87.04,85.34 84.46,82.76 v1(84.46,82.11)
  BOTTOM w0.147: R485.1 v1(84.46,82.11)
ICSSM_MII1_RXD1: length 21.4
  TOP w0.147: U84.12 v1(94.14,90.35)
  BOTTOM w0.147: v1(94.14,90.35) 94.61,89.87 94.61,89.1 93.95,88.44 93.95,88.16 93.82,88.03 93.45,88.03 93.32,87.9 93.32,87.72 93.45,87.59 93.82,87.59 93.95,87.46 93.95,87.28 93.82,87.15 93.45,87.15 93.32,87.02 93.32,86.84 93.45,86.71 93.82,86.71 93.95,86.58 93.95,86.3 93.76,86.11 90.35,86.11 89.99,85.74 89.99,84.69 89.63,84.34 88.7,84.34 88.57,84.46 88.57,84.86 88.44,84.99 88.25,84.99 88.13,84.86 88.13,84.46 88,84.34 87.81,84.34 87.68,84.46 87.68,84.86 87.55,84.99 87.37,84.99 87.24,84.86 87.24,84.46 87.11,84.34 86.73,84.34 86.19,83.79 85.94,83.79 85.82,83.92 85.82,84.16 85.69,84.29 85.5,84.29 85.37,84.16 85.37,83.92 85.24,83.79 84.94,83.79 84.59,84.14 U89.39
ICSSM_MII1_RXD1_ADD: length 46.6
  TOP w0.147: U84.27 88.65,90.35 88.31,90.69 88.31,91.23 87.83,91.72 87.83,94.45 87.61,94.66 86.64,94.66 86.42,94.88 86.42,95.18 86.59,95.35 87.26,95.35 87.43,95.52 87.43,95.77 87.26,95.94 86.59,95.94 86.42,96.11 86.42,97.18 86.25,97.36 86.03,97.36 85.84,97.16 85.84,94.95 84.95,94.06 82.97,94.06 82.09,94.94 v1(82.09,95.4)
  BOTTOM w0.147: v1(82.09,95.4) 82.09,95.18 77.2,90.29 77.2,84.69 78.86,83.03 78.86,79.17 79.34,78.69 79.34,73.91 78.61,73.18 77.13,73.18 76.94,72.98 R526.1
ICSSM_MII1_RXD1_ON: length 17.6
  TOP w0.147: U84.26 v1(89.06,90.85)
  L08_SIG2 w0.091: v1(84.46,81.12) 83.93,81.65 83.93,82.81 85.94,84.82 85.94,90.22 86.04,90.32 86.66,90.32 86.83,90.14 86.83,88.99 87.03,88.79 87.57,88.79 87.76,88.98 87.76,90.04 88.57,90.85 v1(89.06,90.85)
  BOTTOM w0.147: R486.1 v1(84.46,81.12)
ICSSM_MII1_RXD2: length 21.5
  TOP w0.147: v1(95.05,91.35) 94.55,90.85 U84.13
  BOTTOM w0.147: U89.38 86.58,84.85 87.07,85.33 88.49,85.33 88.6,85.44 88.6,85.63 88.45,85.77 87.69,85.77 87.56,85.9 87.56,86.09 87.69,86.22 88.63,86.22 88.73,86.32 89.24,86.32 89.58,85.99 89.81,85.99 89.95,86.13 89.95,86.41 89.7,86.67 89.7,87.06 89.95,87.31 90.32,87.31 90.6,87.02 92.74,87.02 92.95,87.23 92.95,88.08 93.36,88.49 93.36,88.89 93.57,89.11 94.17,89.11 94.3,89.24 94.3,89.42 94.17,89.55 93.08,89.55 92.95,89.68 92.95,89.89 93.91,90.86 94.56,90.86 v1(95.05,91.35)
ICSSM_MII1_RXD2_ADD: length 46.6
  TOP w0.147: v1(83.09,94.89) 83.09,95.89 83.26,96.06 83.47,96.06 83.64,95.89 83.64,94.56 83.84,94.36 84.83,94.36 85.49,95.02 85.49,97.47 85.87,97.84 86.53,97.84 86.72,97.65 86.72,97.1 88.21,95.61 88.21,92.02 88.88,91.35 U84.25
  BOTTOM w0.147: v1(83.09,94.89) 82.58,94.89 82.29,94.6 81.94,94.6 77.55,90.21 77.55,84.76 79.17,83.14 79.17,79.32 79.7,78.8 79.7,72.88 78.83,72.02 78.48,72.02 78.38,72.12 77.07,72.12 76.94,71.99 R527.1
ICSSM_MII1_RXD2_ON: length 18.2
  TOP w0.147: U84.24 v1(89.06,91.85)
  L08_SIG2 w0.091: v1(89.06,91.85) 89.06,91.47 88.94,91.35 88.74,91.35 88.6,91.49 88.6,91.85 88.43,92.03 88.2,92.03 87.46,91.28 86.12,91.28 85.66,90.83 85.66,85 83.66,82.99 83.66,80.89 v1(84.46,80.09)
  BOTTOM w0.147: R487.1 v1(84.46,80.09)
ICSSM_MII1_RXD3: length 21.3
  TOP w0.147: U84.14 v1(94.14,91.35)
  BOTTOM w0.147: v1(94.14,91.35) 93.68,91.35 93.53,91.19 93.06,91.19 92.89,91.02 92.89,90.79 92.65,90.55 90.47,90.55 90.26,90.34 90.26,89.65 90.41,89.5 92.51,89.5 92.94,89.06 92.94,88.59 92.54,88.18 90.08,88.18 89.94,88.05 89.94,87.75 89.79,87.6 89.5,87.6 89.34,87.76 89.34,88.09 89.2,88.24 88.92,88.24 88.69,88.01 88.69,87.83 88.95,87.57 88.95,87.39 88.82,87.26 88.64,87.26 88.38,87.52 88.2,87.52 88.07,87.39 88.07,87.2 88.33,86.95 88.33,86.76 88.2,86.63 88.01,86.63 87.76,86.89 87.57,86.89 87.26,86.58 87.26,85.78 87.11,85.63 86.77,85.63 86.55,85.85 U89.36
ICSSM_MII1_RXD3_ADD: length 46.7
  TOP w0.147: v1(84.09,94.89) 85.2,95.99 85.2,99.36 85.66,99.83 86.67,99.83 87.01,99.49 87.01,97.22 88.5,95.74 88.5,92.66 88.81,92.35 U84.23
  BOTTOM w0.147: R528.1 76.94,71 77.07,71.13 78.53,71.13 80.05,72.65 80.05,78.91 79.49,79.47 79.49,83.24 77.9,84.83 77.9,90.13 81.94,94.17 83.37,94.17 v1(84.09,94.89)
ICSSM_MII1_RXD3_ON: length 18
  TOP w0.147: U84.22 v1(89.06,92.85)
  L08_SIG2 w0.091: v1(84.46,79.1) 84.46,79.48 84.96,79.98 84.96,82.87 88.54,86.46 88.54,87.71 89.51,88.68 89.51,92.62 89.28,92.85 v1(89.06,92.85)
  BOTTOM w0.147: R488.1 84.07,78.7 v1(84.46,79.1)
ICSSM_MII1_RXDV: length 21.6
  TOP w0.147: U84.15 94.55,91.85 v1(95.05,92.35)
  BOTTOM w0.147: v1(95.05,92.35) 95.05,93.63 94.94,93.75 94.72,93.75 94.59,93.63 94.59,92.16 94.5,92.06 94.5,92.05 94.25,91.8 93.59,91.8 93.37,91.58 92.63,91.58 92.63,91.59 90.14,91.59 89.52,90.96 89.52,89.56 89.35,89.39 88.77,89.39 88.61,89.55 88.61,91.12 88.5,91.22 88.3,91.22 88.17,91.09 88.17,87.99 87.02,86.85 U89.34
ICSSM_MII1_RXDV_ADD: length 46.3
  TOP w0.147: R529.1 77.6,69.67 78.08,70.16 78.9,70.16 79.14,70.4 79.14,71.43 79.78,72.08 79.78,78.63 79.34,79.07 79.34,84.67 78.24,85.77 78.24,94.74 v1(78.06,94.93) ; U84.21 v1(90.85,94.14)
  BOTTOM w0.147: v1(78.06,94.93) 78.77,94.93 79.33,94.37 79.85,94.37 80.28,94.8 80.28,95.33 79.98,95.63 79.5,95.63 79.31,95.82 79.31,96.22 79.61,96.51 81.85,96.51 82.95,95.42 85.71,95.42 86.57,94.56 90.43,94.56 v1(90.85,94.14)
ICSSM_MII1_RXDV_ON: length 18.2
  TOP w0.147: v1(96.39,94.94) 96.91,94.42 100.27,94.42 100.55,94.7 100.55,95.17 100.27,95.44 96.14,95.44 95.28,94.59 91.56,94.59 91.35,94.38 U84.20
  BOTTOM w0.147: v1(96.39,94.94) 96.85,94.94 97.35,95.44 97.89,95.44 98.4,94.93 R489.1
ICSSM_MII1_RXER: length 21.4
  TOP w0.147: U84.16 v1(94.14,92.35)
  BOTTOM w0.147: v1(94.14,92.35) 94.13,92.34 93.52,92.34 93.07,91.89 90.53,91.89 90.17,92.25 90.17,93.07 90.02,93.23 89.69,93.23 89.52,93.06 89.52,91.47 89.38,91.32 88.91,91.32 88.5,91.73 88.5,93.19 88.31,93.38 88.04,93.38 87.87,93.21 87.87,92.31 87.74,92.19 87.31,92.19 87.19,92.06 87.19,91.87 87.31,91.74 87.74,91.74 87.87,91.61 87.87,89.48 87.74,89.35 87.34,89.35 87.21,89.22 87.21,89.04 87.34,88.91 87.74,88.91 87.87,88.78 87.87,88.25 87.47,87.85 U89.32
ICSSM_MII1_RXER_ADD: length 46.5
  TOP w0.147: v1(78.06,95.93) 78.6,95.39 78.6,85.91 79.69,84.81 79.69,79.21 80.14,78.77 80.14,71.93 79.47,71.26 79.47,69.89 78.72,69.14 78.06,69.14 77.6,68.68 R530.1 ; U84.19 v1(91.85,94.14)
  BOTTOM w0.147: v1(78.06,95.93) 79.06,96.93 81.85,96.93 83.07,95.71 85.83,95.71 86.69,94.85 91.13,94.85 v1(91.85,94.14)
ICSSM_MII1_RXER_ON: length 18.3
  TOP w0.147: U84.18 92.35,94.01 92.64,94.3 92.96,94.3 93.13,94.12 93.13,93.7 93.3,93.53 93.55,93.53 93.72,93.7 93.72,94.12 93.89,94.3 94.41,94.3 94.64,94.06 94.64,93 94.81,92.83 95.05,92.83 95.24,93.02 95.24,94.06 95.37,94.19 95.65,94.19 95.81,94.03 95.81,92.25 95.55,91.99 95.55,90.92 95.75,90.72 96.71,90.72 96.86,90.87 96.86,93.48 v1(96.39,93.95)
  BOTTOM w0.147: R490.1 98.4,93.94 97.89,94.45 97.35,94.45 96.85,93.95 v1(96.39,93.95)
ICSSM_MII1_RXLINK: length 21.7
  TOP w0.147: U84.3 94.14,85.85 94.95,85.04 94.95,83.95 93.15,82.15 88.71,82.15 88.35,82.51 88.35,83.3 87.78,83.88 87.78,88.63 86.84,89.57 86.84,90.39 v1(87.29,90.85)
  BOTTOM w0.147: U89.27 86.79,90.35 v1(87.29,90.85)
ICSSM_MII1_RXLINK_ADD: length 46.2
  TOP w0.147: U84.39 90.85,84.06 v1(90.35,83.56) ; R532.1 v1(77.6,66.7)
  L08_SIG2 w0.091: v1(77.6,66.7) 78.14,66.16 78.89,66.16 79.68,66.95 79.68,70.67 81.52,72.51 81.52,76.11 83.59,78.18 85.24,78.18 89.51,82.44 90.52,82.44 90.68,82.6 90.68,82.85 90.57,82.96 89.96,82.96 89.77,83.15 89.77,87.53 89.93,87.7 90.09,87.7 90.23,87.56 90.23,86.29 90.6,85.93 92.5,85.93 92.87,86.29 92.87,88.45 92.96,88.54 93.14,88.54 93.24,88.45 93.24,85.41 92.27,84.45 90.7,84.45 90.35,84.1 v1(90.35,83.56)
ICSSM_MII1_RXLINK_ON: length 17.7
  TOP w0.147: U84.40 v1(91.35,83.56)
  L08_SIG2 w0.091: v1(96.39,91.96) 95.9,91.47 95.9,89.89 95.57,89.57 95.01,89.57 94.57,89.13 94.57,85.62 95.13,85.07 95.13,84.64 94.07,83.58 94.07,83.1 93.27,82.3 92.28,82.3 91.35,83.23 v1(91.35,83.56)
  BOTTOM w0.147: v1(96.39,91.96) 96.85,91.96 97.35,92.47 97.89,92.47 98.4,91.96 R492.1
ICSSM_MII1_TXCLK: length 10.5
  TOP w0.147: U85.12 v1(94.14,103.34)
  L03_SIG1 w0.091: v1(94.14,103.34) 94.14,103.65 93.36,104.42 93.36,105.27 93.24,105.39 93.02,105.39 92.91,105.28 92.91,105.1 92.65,104.84 90.65,104.84 89.43,106.06 89.15,106.06 88.79,106.42 v1(88.79,107.46)
  BOTTOM w0.147: R1399.1 v1(88.79,107.46)
ICSSM_MII1_TXCLK_ADD: length 46.9
  TOP w0.147: R512.1 v1(68.45,82.81) ; v1(69.56,99.82) 70.11,100.37 74.67,100.37 76.06,101.76 76.06,103.05 80.32,107.3 82.19,107.3 82.87,106.62 86.9,106.62 87.56,105.96 87.56,103.65 87.88,103.34 U85.27
  L03_SIG1 w0.091: v1(68.45,82.81) 68.45,88.93 69.53,90.02 69.53,92.99 71.53,94.98 71.53,96.75 70.48,97.8 70.48,98.9 v1(69.56,99.82)
ICSSM_MII1_TXCLK_ON: length 19.9
  TOP w0.147: U85.26 v1(89.06,103.84)
  L08_SIG2 w0.091: v1(89.06,103.84) 90.48,102.42 92.8,102.42 93.24,102.86 93.24,104.54 93.53,104.83 95.5,104.83 95.81,104.51 95.81,102.66 96.23,102.24 97.25,102.24 97.7,101.8 97.7,100.04 v1(96.56,98.91)
  BOTTOM w0.147: v1(96.56,98.91) 97.07,99.41 97.82,99.41 R504.1
ICSSM_MII1_TXD0: length 15.4
  TOP w0.147: v1(95.05,104.34) 94.55,103.84 U85.13
  BOTTOM w0.147: U88.29 89.29,102.34 89.48,102.52 93.41,102.52 93.55,102.67 93.73,102.84 94.54,102.84 95.21,102.17 95.7,102.17 95.9,102.37 95.9,103.87 95.43,104.34 v1(95.05,104.34)
ICSSM_MII1_TXD0_ADD: length 46.9
  TOP w0.147: v1(78.31,74.65) 77.79,75.17 77.18,75.17 76.86,74.86 R513.1 ; v1(88.15,105.34) 88.15,104.68 88.49,104.34 U85.25
  L08_SIG2 w0.091: v1(88.15,105.34) 88.2,105.39 88.2,106.34 87.95,106.59 87.59,106.59 87.33,106.33 87.33,105.29 87.02,104.98 86.86,104.98 86.51,105.34 86.09,105.34 85.29,104.54 85.29,104.05 84.69,103.45 82.45,103.45 81.66,102.67 80.72,102.67 79.58,101.54 79.58,95.23 77.94,93.58 77.94,80.23 76.39,78.69 76.39,77.7 76.58,77.51 76.83,77.26 76.83,76.38 77.11,76.1 77.11,75.39 77.37,75.13 77.64,75.13 78.13,74.65 v1(78.31,74.65)
ICSSM_MII1_TXD0_ON: length 20.1
  TOP w0.147: v1(96.56,103.03) 97.03,103.49 97.03,105.63 97.21,105.81 97.21,107.14 96.23,108.12 90.21,108.12 88.26,106.16 88.26,105.95 88.61,105.6 88.61,105.06 88.83,104.84 U85.24
  BOTTOM w0.147: v1(96.56,103.03) 97.07,103.53 98.57,103.53 99.07,103.03 R505.1
ICSSM_MII1_TXD1: length 15.3
  TOP w0.147: U85.14 v1(94.14,104.34)
  BOTTOM w0.147: U88.27 86.73,103.34 86.9,103.16 86.9,102.91 87.09,102.73 87.33,102.73 87.49,102.89 87.49,103.44 88.01,103.95 88.01,104.65 88.18,104.82 88.42,104.82 88.6,104.65 88.6,103.51 88.77,103.34 89.41,103.34 89.67,103.6 89.67,104.06 89.8,104.18 90.05,104.18 90.2,104.03 90.2,103.78 90.39,103.6 92.68,103.6 92.88,103.39 92.88,103.09 93.03,102.94 93.32,102.94 93.53,103.15 93.53,104.15 93.71,104.34 v1(94.14,104.34)
ICSSM_MII1_TXD1_ADD: length 47
  TOP w0.147: v1(78.31,75.68) 77.84,76.15 77.31,76.15 76.87,75.71 R514.1 ; v1(89.06,105.34) U85.23
  L08_SIG2 w0.091: v1(89.06,105.34) 88.06,104.33 86.16,104.33 85.56,103.73 85.56,103.19 84.71,102.33 82.59,102.33 82.15,101.89 82.15,100.49 82.52,100.11 84.99,100.11 85.22,99.88 85.22,99.19 85.02,98.99 82.34,98.99 81.68,98.33 80.43,98.33 79.99,97.89 79.99,94.85 78.21,93.07 78.21,80.19 76.71,78.68 76.71,77.77 77.11,77.37 77.11,76.5 77.46,76.14 77.85,76.14 78,75.99 78,75.99 v1(78.31,75.68)
ICSSM_MII1_TXD1_ON: length 20.2
  TOP w0.147: U85.22 89.65,105.84 89.3,106.18 v1(89.3,106.55)
  L03_SIG1 w0.091: v1(89.3,106.55) 89.52,106.55 90.22,105.85 90.36,105.85 90.47,105.96 90.47,106.45 90.57,106.56 90.73,106.56 90.83,106.45 90.83,105.96 90.94,105.85 91.09,105.85 91.2,105.96 91.2,106.45 91.31,106.56 91.46,106.56 91.56,106.45 91.56,105.96 91.67,105.85 91.82,105.85 91.93,105.96 91.93,106.45 92.04,106.56 92.19,106.56 92.3,106.45 92.3,105.96 92.4,105.85 92.7,105.85 92.86,106 92.86,107.09 93.07,107.3 94.27,107.3 94.4,107.18 94.4,106.95 94.29,106.84 93.88,106.84 93.64,106.6 93.64,105.1 93.91,104.83 95.76,104.83 v1(96.56,104.02)
  BOTTOM w0.147: R506.1 99.07,104.02 98.57,104.52 97.07,104.52 v1(96.56,104.02)
ICSSM_MII1_TXD2: length 15.3
  TOP w0.147: v1(95.05,105.34) 94.55,104.84 U85.15
  BOTTOM w0.147: v1(95.05,105.34) 94.53,104.82 93.2,104.82 92.99,104.61 90.07,104.61 89.73,104.95 89.73,105.88 89.51,106.09 87.56,106.09 87.27,105.8 87.27,104.93 87.58,104.61 87.58,104.29 87.27,103.97 86.89,103.97 86.57,104.29 86.55,104.29 86.51,104.34 U88.25
ICSSM_MII1_TXD2_ADD: length 47.3
  TOP w0.147: R515.1 76.87,76.91 77.12,77.16 77.82,77.16 v1(78.31,76.67) ; U85.21 v1(90.85,107.07)
  L08_SIG2 w0.091: v1(90.85,107.07) 90.51,106.73 90.51,106.39 91.02,105.88 92.66,105.88 92.97,105.57 92.97,105.29 92.24,104.56 88.71,104.56 87.45,103.3 86.1,103.3 85.53,102.73 85.53,95.29 84.37,94.13 81.18,94.13 78.48,91.44 78.48,80.15 77.03,78.69 77.03,77.95 v1(78.31,76.67)
ICSSM_MII1_TXD2_ON: length 19.8
  TOP w0.147: U85.20 91.35,107.27 91.09,107.53 90.22,107.53 90.04,107.35 v1(90.04,106.97)
  L03_SIG1 w0.091: v1(90.04,106.97) 90.72,107.64 94.43,107.64 94.72,107.36 94.72,105.98 94.91,105.8 95.23,105.8 95.41,105.98 95.41,107.43 95.63,107.64 97.4,107.64 97.75,107.29 97.75,105.69 97.08,105.01 v1(96.56,105.01)
  BOTTOM w0.147: v1(96.56,105.01) 99.08,105.01 R507.1
ICSSM_MII1_TXD3: length 15
  TOP w0.147: U85.16 v1(94.14,105.34)
  BOTTOM w0.147: U88.23 86.52,105.34 86.83,105.65 86.83,106.43 87.08,106.68 88.74,106.68 89.62,107.56 91.1,107.56 91.33,107.34 91.33,106.72 90.17,105.57 90.17,105.18 90.42,104.94 92.72,104.94 93.12,105.34 v1(94.14,105.34)
ICSSM_MII1_TXD3_ADD: length 47.3
  TOP w0.147: U85.19 v1(91.85,107.07) ; R516.1 77.61,77.98 78.02,78.39 78.2,78.39 v1(78.25,78.44)
  L08_SIG2 w0.091: v1(91.85,107.07) 94.99,107.07 95.38,106.68 95.38,106.11 95.16,105.88 93.95,105.88 92.97,104.91 92.97,103.81 92.59,103.44 90.42,103.44 89.57,104.29 88.83,104.29 88.52,103.98 88.52,103.77 86.93,102.18 86.34,102.18 85.82,101.66 85.82,95.19 84.48,93.86 81.29,93.86 78.76,91.32 78.76,78.95 v1(78.25,78.44)
ICSSM_MII1_TXD3_ON: length 20.2
  TOP w0.147: v1(96.56,106) 96.85,106.29 96.85,106.53 96.7,106.68 96.46,106.68 96.04,106.26 96.04,102.71 95.89,102.57 95.69,102.57 95.54,102.72 95.54,105.97 95.39,106.12 94.89,106.12 94.71,106.29 94.71,106.53 94.93,106.74 95.75,106.74 95.87,106.86 95.87,107.07 95.71,107.23 93.58,107.23 93.45,107.1 93.45,106.71 93.32,106.58 93.14,106.58 93.01,106.71 93.01,107.1 92.88,107.23 92.53,107.23 92.35,107.06 U85.18
  BOTTOM w0.147: v1(96.56,106) 97.05,105.51 98.6,105.51 R508.1
ICSSM_MII1_TXEN: length 15.1
  TOP w0.147: U85.11 94.55,102.84 v1(95.05,103.34)
  L03_SIG1 w0.091: v1(95.05,103.34) 94.6,102.89 93.94,102.89 93.47,103.36 93.47,103.75 92.65,104.56 90.45,104.56 89.25,105.76 89.24,105.76 89.24,105.76 88.96,105.76 87.6,107.12 v1(85.09,107.12)
  BOTTOM w0.147: v1(85.09,107.12) 84.59,106.62 U88.21
ICSSM_MII1_TXEN_ADD: length 46.7
  TOP w0.147: U85.29 87.51,102.34 87.02,102.83 87.02,106.06 86.77,106.31 86.04,106.31 85.64,105.9 85.06,105.9 84.66,106.31 82.74,106.31 82.06,106.99 80.44,106.99 76.37,102.92 76.37,101.63 74.55,99.82 v1(70.48,99.82) ; R511.1 v1(69.44,82.81)
  L03_SIG1 w0.091: v1(69.44,82.81) 69.44,83.71 70.35,84.62 70.35,87.83 72,89.48 72,98.29 v1(70.48,99.82)
ICSSM_MII1_TXEN_ON: length 19.8
  TOP w0.147: U85.28 v1(89.06,102.84)
  L08_SIG2 w0.091: v1(96.56,99.9) 96.11,100.36 93.81,100.36 93.52,100.07 93.52,99.59 93.8,99.31 95.61,99.31 95.85,99.07 95.85,98.58 95.6,98.34 93.71,98.34 92.93,99.12 92.93,101.06 92.64,101.36 90.54,101.36 v1(89.06,102.84)
  BOTTOM w0.147: v1(96.56,99.9) 97.07,100.4 97.81,100.4 98.31,99.9 R503.1
IO_EXP_INTN: length 2.4
  BOTTOM w0.147: R395.1 59.29,73.6 58.89,73.21 58.3,73.21 57.96,72.86 U60.32
JTAG_MUX1_OE#: length 4.6
  TOP w0.147: U30.15 39.68,63.04 39.97,62.76 C178.2 R189.1
JTAG_MUX_SEL: length 4.2
  TOP w0.147: SW1.1 30.11,64.75 29.98,64.62 R188.1 30.11,64.03 30.44,63.69 U30.1
JTAG_TDO2/GPIO_1: length 2.7
  BOTTOM w0.147: U35.22 R245.1 R233.1
LED2_2: length 27.7
  TOP w0.147: v1(106.6,85.09) 106.6,84.2 103.11,80.71 101.47,80.71 99.89,79.13 99.05,79.13 v1(98.08,78.16)
  BOTTOM w0.147: v1(98.08,78.16) 95.4,78.16 95.18,78.38 R229.2 93.87,78.38 93.09,79.16 91.54,79.16 91.31,78.92 R241.1 91.31,78.29 90.7,77.68 90.7,73.35 90.42,73.08 U35.45 ; v1(106.6,85.09) 106.6,84.64 106.44,84.48 R221.1
LIN2_RXD: length 25.5
  TOP w0.147: v1(52,60.27) 50,60.27 48.51,61.77 48.51,62.87 47.72,63.66 U20.4 ; U1.B8 v1(58.58,46.43)
  L03_SIG1 w0.091: v1(52,60.27) 52,57.68 57.2,52.48 57.2,50.46 58.39,49.26 58.39,48.15 58.19,47.95 58.19,46.82 v1(58.58,46.43)
LIN2_TXD: length 23.1
  TOP w0.147: U1.A8 v1(58.58,47.23) ; v1(52.58,59.29) 49.46,59.29 47.05,61.71 U20.7
  L03_SIG1 w0.091: v1(52.58,59.29) 52.84,59.03 52.84,57.2 57.5,52.54 57.5,50.56 58.9,49.16 58.9,47.55 v1(58.58,47.23)
LIN_EN: length 1.9
  TOP w0.147: R285.1 U45.2
LIN_MUX_OE#: length 2.5
  BOTTOM w0.147: U44.15 35.98,67.83 36.55,68.41 R280.1
LIN_MUX_SEL: length 43.4
  TOP w0.147: v1(55.46,65.73) 56.35,65.73 56.97,66.34 56.97,66.86 56.19,67.63 54.88,67.63 52.51,70 52.51,70.82 51.94,71.39 49.5,71.39 48.35,72.55 45.86,72.55 41.17,67.85 28.98,67.85 v1(27.54,66.42)
  BOTTOM w0.147: R277.2 26.92,66.59 27.09,66.42 v1(27.54,66.42) ; R277.2 27.57,67.3 27.69,67.18 U44.1 ; R277.2 26.92,67.9 26.92,67.91 R279.1 ; U60.14 v1(55.46,65.73)
LIN_UART1_RXD: length 8.6
  TOP w0.147: R284.1 v1(27.14,63.08)
  BOTTOM w0.147: U44.2 29.82,67.83 30.07,67.58 30.07,65.14 28.01,63.08 v1(27.14,63.08)
LIN_UART1_TXD: length 3.7
  TOP w0.147: R283.1 26.17,68.85 27.1,69.78 v1(27.55,69.78)
  BOTTOM w0.147: U44.5 v1(27.55,69.78)
MCAN1_STB: length 89.1
  TOP w0.147: v1(16.38,21.63) R466.2 17.66,21.63 17.93,21.91 U29.14
  L08_SIG2 w0.091: v1(18.25,38.08) 17.64,38.69 17.64,54.03 21.44,57.83 21.44,60.43 26.63,65.62 38.32,65.62 39.15,66.45 40.56,66.45 41.12,67.01 51.03,67.01 v1(52.75,68.74)
  BOTTOM w0.147: U60.18 v1(52.75,68.74) ; v1(16.38,21.63) 16.38,25.05 14.98,26.46 11.08,26.46 10.16,27.37 10.16,31.88 10.82,32.54 14.29,32.54 18.25,36.5 v1(18.25,38.08)
MCAN4_CAN_H: length 9.9
  TOP w0.104: U29.13 18.04,22.41 17.92,22.53 16.08,22.53 R171.1 15.09,22.59 13.58,22.59 13.33,22.34 13.33,20.31 13.08,20.05 J5.1
MCAN4_CAN_L: length 9.6
  TOP w0.104: U29.12 18.04,22.91 17.92,22.78 16.08,22.78 R174.2 15.22,22.85 15.2,22.85 15.19,22.84 13.59,22.84 13.33,23.1 13.33,24.88 13.08,25.13 11.55,25.13
MCAN4_RX: length 10
  TOP w0.147: R173.1 26.88,23.83 26.96,23.91 26.96,27.85 28.31,29.2 v1(30.22,29.2)
  BOTTOM w0.147: U33.2 30.2,29.22 v1(30.22,29.2)
MCAN4_RX_R: length 4.3
  TOP w0.147: R173.2 24.84,23.05 24.49,23.41 U29.4
MCAN4_T: length 7
  TOP w0.147: R174.1 C176.1 v1(14.75,25.28) ; v1(14.75,21.09) R171.2
  BOTTOM w0.147: v1(14.75,25.28) v1(14.75,21.09)
MCAN4_TX: length 24.9
  TOP w0.147: R172.2 v1(19.05,20.05)
  BOTTOM w0.147: U33.5 27.1,31.17 25.66,32.61 18.75,32.61 17.8,31.66 17.8,27.24 19.05,26 v1(19.05,20.05)
MCAN4_TX_R: length 2.9
  TOP w0.147: R172.1 20.61,21.62 20.9,21.91 U29.1
MCAN_EN: length 2.6
  TOP w0.147: U29.6 22.66,24.41 23.84,25.58 R1647.2
MDIO0_MDC: length 26.9
  TOP w0.147: U1.M17 v1(66.58,37.63)
  L03_SIG1 w0.091: v1(74.41,33.45) 73.39,34.48 73.39,37.91 74.08,38.6 76.04,38.6 v1(77.4,37.24)
  BOTTOM w0.147: v1(66.58,37.63) 67.2,37.01 70.85,37.01 v1(74.41,33.45) R436.2 74.41,29.61 75.14,28.88 U81.3 ; U90.3 v1(77.4,37.24)
MDIO0_MDIO: length 26.9
  TOP w0.147: U1.N16 v1(65.78,36.83)
  L03_SIG1 w0.091: v1(73.43,33.45) 72.91,33.98 72.91,37.97 74.16,39.23 v1(76.9,39.23)
  BOTTOM w0.114: 66.82,36.43 66.18,36.43 v1(65.78,36.83)
  BOTTOM w0.147: 66.82,36.43 66.99,36.43 67.18,36.61 70.74,36.61 73.43,33.91 v1(73.43,33.45) R437.2 73.43,29.03 72.79,28.38 U81.7 ; U90.7 v1(76.9,39.23)
MDIO/MDC_MUX_SEL1: length 116.4
  TOP w0.147: v1(40.47,32.79) 39.3,33.96 39.3,36.15 38.63,36.82 37.97,36.82 37.67,37.12 37.67,40.37 38.22,40.91 38.58,40.91 39.3,41.62 39.3,43.76 40.17,44.64 40.17,47.31 44.91,52.04 44.91,54.15 46.11,55.35 46.11,56.09 44.77,57.43 44.77,59.04 43.53,60.27 43.53,61.44 43.99,61.9 43.99,68.79 45.34,70.14 47.23,70.14 47.71,69.65 v1(51.86,69.65) ; v1(43.67,27.61) 45.22,26.05 47.37,26.05 51.1,22.32 61.12,22.32 61.92,23.12 66.01,23.12 69.54,26.66 80.52,26.66 81.74,27.88 82.98,27.88 83.61,28.51 v1(83.61,30.68)
  BOTTOM w0.147: v1(51.86,69.65) 52.28,69.24 U60.19 ; v1(40.47,32.79) 41.62,32.79 43.67,30.74 v1(43.67,27.61) ; U81.1 R474.1 78.82,31.36 79.49,30.68 v1(83.61,30.68)
MDIO/MDC_MUX_SEL2: length 117.4
  TOP w0.147: v1(52,70.55) 49.32,70.55 47.73,72.14 45.96,72.14 42.56,68.74 42.56,62.4 42.95,62.02 42.95,60.88 42.49,60.42 42.49,59.84 44.47,57.85 44.47,57.31 45.82,55.96 45.82,55.47 44.62,54.27 44.62,52.17 39.88,47.43 39.88,44.76 39,43.88 39,41.74 38.46,41.2 38.09,41.2 37.38,40.49 37.38,36.19 38.88,34.68 38.88,33.36 v1(39.45,32.79) ; v1(44.38,28.33) 45.7,27 54.4,27 54.98,26.42 57.7,26.42 58.24,26.96 80.41,26.96 81.65,28.21 82.85,28.21 83.13,28.49 83.13,31.11 v1(83.61,31.59)
  BOTTOM w0.147: v1(44.38,28.33) 44.38,30.74 41.81,33.32 39.98,33.32 v1(39.45,32.79) ; U90.1 R3871.2 78.4,32.61 79.74,31.27 83.29,31.27 v1(83.61,31.59) ; v1(52,70.55) 52,70.54 52.8,69.74 U60.20
MMC0_CLK: length 1.7
  TOP w0.147: RA2.4 50.92,48.56 50.92,48.41 50.99,48.34 v1(50.99,48.23)
  BOTTOM w0.147: v1(50.99,48.23) 50.99,48.73 R123.1
MMC0_CLK_R: length 39.6
  TOP w0.147: v1(29.33,52.18) 28.68,51.53 R132.2
  L03_SIG1 w0.091: v1(52.6,49.77) 46.81,49.77 45.96,48.92 45.96,48.02 45.71,47.76 44.58,47.76 44.14,48.21 44.14,49.58 43.6,50.11 43.6,52.94 43.6,53.17 42.88,53.89 31.22,53.89 31.21,53.88 31.03,53.88 v1(29.33,52.18)
  BOTTOM w0.147: v1(52.6,49.77) R134.1 R123.2 ; U24.6 29.18,51.28 29.33,51.43 v1(29.33,52.18) 28.76,52.76 26.32,52.76 25.79,52.23 J4.5
MMC0_CMD: length 40.6
  TOP w0.147: R131.2 26.41,51.3 v1(26.92,50.79) ; RA4.3 46.35,48.51 46.61,48.24 v1(46.69,48.24)
  L03_SIG1 w0.091: v1(26.92,50.79) 25.64,50.79 25.55,50.88 25.55,52.35 25.63,52.43 25.74,52.43 25.82,52.35 25.82,51.39 25.9,51.31 26.02,51.31 26.1,51.39 26.1,52.35 26.18,52.43 26.29,52.43 26.37,52.35 26.37,51.39 26.45,51.31 26.57,51.31 26.65,51.39 26.65,52.35 26.73,52.43 26.84,52.43 26.92,52.35 26.92,51.39 27.13,51.17 30.19,51.17 32.36,53.34 41.68,53.34 42.96,52.07 42.96,49.98 43.59,49.35 43.59,47.98 44.35,47.21 45.96,47.21 46.69,47.95 v1(46.69,48.24)
  BOTTOM w0.147: J4.3 26.16,50.03 v1(26.92,50.79) 26.92,50.78 U24.3
MMC0_DAT0: length 42.6
  TOP w0.147: v1(50.23,48.24) 50.16,48.24 49.9,48.51 RA2.3 ; R127.2 29.01,49.9 29.46,50.34 29.46,51.17 v1(29.97,51.68)
  L03_SIG1 w0.091: v1(29.97,51.68) 29.97,52.25 31.33,53.61 32.24,53.61 32.25,53.62 42.77,53.62 43.33,53.06 43.33,50 43.86,49.46 43.86,48.09 44.47,47.49 45.83,47.49 46.26,47.92 46.26,48.72 46.97,49.42 48.58,49.42 48.7,49.31 48.7,49.15 48.6,49.05 47.75,49.05 47.62,48.92 47.62,48.79 47.74,48.67 49.8,48.67 v1(50.23,48.24)
  BOTTOM w0.147: U24.7 29.71,50.78 29.97,51.04 v1(29.97,51.68) 29.97,52.54 29.28,53.23 26.36,53.23 25.16,54.43 J4.7
MMC0_DAT1: length 42.2
  TOP w0.147: R128.2 29.24,48.92 29.97,49.64 v1(29.97,50.15) ; v1(49.14,48.25) 49.4,48.51 49.4,48.94
  L03_SIG1 w0.091: v1(49.14,48.25) 48.2,47.3 47.28,47.3 46.32,46.34 43.79,46.34 41.14,48.98 41.14,51.97 40.85,52.26 39.44,52.26 38.01,50.83 35.33,50.83 35.25,50.75 35.25,50.64 35.33,50.56 36.57,50.56 36.65,50.48 36.65,50.36 36.57,50.28 34.84,50.28 34.29,50.83 32.15,50.83 31.47,50.15 v1(29.97,50.15)
  BOTTOM w0.147: J4.8 25.16,55.53 26.94,53.74 29.33,53.74 30.52,52.55 30.52,50.84 30.29,50.6 30.29,50.47 v1(29.97,50.15) 29.84,50.28 29.77,50.28 29.76,50.28 U24.8
MMC0_DAT2: length 41.7
  TOP w0.147: RA2.1 48.26,48.43 v1(48.26,48.25) ; R129.2 26.85,48.76 26.97,48.88 v1(27.43,48.88)
  L03_SIG1 w0.091: v1(27.43,48.88) 27.43,48.46 27.59,48.3 29.1,48.3 29.39,48.59 29.39,49.24 29.31,49.32 27.93,49.32 27.85,49.4 27.85,49.51 27.93,49.59 29.31,49.59 29.39,49.67 29.39,49.79 29.31,49.87 27.93,49.87 27.85,49.95 27.85,50.22 28.25,50.62 31.16,50.62 31.73,51.19 37.86,51.19 39.21,52.54 41.71,52.54 42.28,51.97 42.28,48.23 43.9,46.61 46.15,46.61 47.16,47.63 47.63,47.63 v1(48.26,48.25)
  BOTTOM w0.147: J4.1 26.38,47.83 v1(27.43,48.88) 27.81,49.26 U24.1
MMC0_DAT3: length 40.8
  TOP w0.147: v1(47.45,48.24) 47.37,48.33 47.37,48.56 RA4.4 ; R130.2 26.67,50.03 v1(26.92,49.77)
  L03_SIG1 w0.091: v1(47.45,48.24) 47.17,47.96 47.11,47.96 46.09,46.94 44.11,46.94 42.65,48.4 42.65,51.99 41.74,52.9 39.02,52.9 37.59,51.47 32.41,51.47 32.31,51.56 32.31,51.68 32.41,51.77 36.12,51.77 36.21,51.86 36.21,51.98 36.12,52.07 31.96,52.07 30.79,50.9 28.05,50.9 v1(26.92,49.77)
  BOTTOM w0.147: U24.2 27.43,50.28 v1(26.92,49.77) 26.08,48.93 J4.2
MMC0_SDCD: length 38.7
  TOP w0.147: v1(45.53,48.19) 45.85,48.51 45.85,48.94
  L03_SIG1 w0.091: v1(29.54,58.41) 32.84,55.12 33.06,55.12 33.14,55.2 33.14,55.31 30.03,58.42 30.03,58.54 30.11,58.62 30.22,58.62 33.87,54.96 42.21,54.96 44.01,53.16 44.01,50.25 45.53,48.73 v1(45.53,48.19)
  BOTTOM w0.147: v1(29.54,58.41) 29.54,57.76 U25.5 27.28,57.75 26.81,57.28 R133.2 J4.9
MMC0_WP: length 3
  TOP w0.147: RA4.1 44.7,48.43 v1(44.7,48.25)
  BOTTOM w0.147: v1(44.7,48.25) 43.97,48.25 R124.1 43.96,47.52 43.97,47.51 TP48.1
MUX_UART1/LIN_RXD: length 42.7
  TOP w0.147: R143.2 v1(58.99,51.73)
  BOTTOM w0.147: U44.4 30.04,69.13 32.42,66.75 32.42,59.23 33.86,57.79 48.96,57.79 52.83,53.92 56.81,53.92 v1(58.99,51.73)
MUX_UART1/LIN_TXD: length 49.7
  BOTTOM w0.147: U44.7 25.95,71.08 24.79,69.91 24.79,64.5 29.46,59.83 31.01,59.83 33.34,57.5 48.68,57.5 52.59,53.59 56.29,53.59 R145.2
OPSI_DQS: length 4.6
  TOP w0.147: U19.C3 v1(32.35,43.16)
  BOTTOM w0.147: R111.1 R112.1 R114.1 R113.1 32.47,43.28 v1(32.35,43.16)
OSC0: length 6.1
  BOTTOM w0.147: Y2.1 26.52,81.99 25.52,82.99 25.52,84.53 25.77,84.78 C269.2 25.77,85.97 25.54,86.2 U52.88
OSC1: length 4.1
  BOTTOM w0.147: U52.89 25.14,86.36 24.75,85.97 C270.2 24.75,83.92 Y2.3
OSC_CLK_OUT: length 1.4
  TOP w0.147: R273.1 U42.3
OSPI0_RESET_OUT0: length 32
  TOP w0.147: v1(45.26,44.47) 45.26,44.1 45.66,43.7 48.94,43.7 R194.2
  L08_SIG2 w0.091: v1(45.26,44.47) 45.26,41.66 44.62,41.02 39.77,41.02 38.49,42.3 35.34,42.3 34.24,41.19 34.24,36.91 32.65,35.32 v1(29.36,35.32)
  BOTTOM w0.147: v1(29.36,35.32) R120.1 U21.1
