# Allegro board PROC159B.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SOC_MMC0_CMD: length 12.8
  TOP w0.147: U1.A4 v1(55.38,47.23) ; v1(46.6,50.53) 46.35,50.28 RA4.6
  L08_SIG2 w0.091: v1(46.6,50.53) 47.03,50.96 49.32,50.96 49.73,50.55 49.73,50.35 51.12,48.96 51.39,48.96 52.21,48.13 54.58,48.13 55.38,47.33 v1(55.38,47.23)
  BOTTOM w0.147: RA5.6 46.3,50.84 v1(46.6,50.53)
SOC_MMC0_DAT0: length 12.5
  TOP w0.147: v1(50.16,50.53) 49.9,50.28 RA2.6 ; U1.B5 v1(56.18,46.43)
  L08_SIG2 w0.091: v1(56.18,46.43) 55.79,46.82 55.79,47.46 55.52,47.73 55.37,47.73 54.68,48.42 53.18,48.42 53.09,48.51 53.09,48.7 53.18,48.79 53.37,48.79 53.46,48.89 53.46,49.08 53.24,49.31 52.5,49.31 52.09,48.9 51.9,48.9 51.81,49 51.81,49.11 51.95,49.26 51.95,49.37 51.87,49.45 51.76,49.45 51.56,49.25 51.34,49.25 51.19,49.4 51.19,49.51 51.25,49.56 51.25,49.68 51.17,49.76 51.05,49.76 51,49.7 50.89,49.7 50.16,50.43 v1(50.16,50.53)
  BOTTOM w0.147: v1(50.16,50.53) 49.85,50.84 RA3.6
SOC_MMC0_DAT1: length 12.8
  TOP w0.147: v1(49.14,50.53) 49.4,50.28 49.4,49.84 ; U1.B4 v1(55.38,46.43)
  L08_SIG2 w0.091: v1(49.14,50.53) 49.14,50.16 49.22,50.08 49.56,50.08 49.64,50 49.64,49.89 49.56,49.81 49.22,49.81 49.14,49.73 49.14,49.44 49.28,49.31 49.67,49.31 49.75,49.23 49.75,48.85 49.92,48.69 50.07,48.69 50.15,48.77 50.15,49.23 50.23,49.31 50.37,49.31 50.99,48.68 51.25,48.68 52.07,47.86 54.07,47.86 54.31,47.62 54.74,47.62 54.99,47.37 54.99,46.83 v1(55.38,46.43)
  BOTTOM w0.147: v1(49.14,50.53) 49.35,50.74 RA3.7
SOC_MMC0_DAT2: length 13.2
  TOP w0.147: v1(48.26,50.53) 48.26,50.35 RA2.8 ; U1.A3 v1(54.58,47.23)
  L08_SIG2 w0.091: v1(54.58,47.23) 54.33,47.23 53.94,47.62 52.73,47.62 52.31,47.2 50.6,47.2 49.69,48.11 49.69,48.53 49.23,48.99 48.56,48.99 48.56,48.99 48.33,48.99 48.23,49.08 48.23,49.25 48.26,49.27 48.26,49.28 48.34,49.36 48.71,49.36 48.79,49.44 48.79,49.56 48.71,49.64 48.34,49.64 48.26,49.72 48.26,49.83 48.34,49.91 48.71,49.91 48.79,49.99 48.79,50.11 48.71,50.19 48.34,50.19 48.26,50.27 v1(48.26,50.53)
  BOTTOM w0.147: v1(48.26,50.53) 48.26,50.74 RA3.8
SOC_MMC0_DAT3: length 12.9
  TOP w0.147: RA4.5 47.37,50.22 v1(47.37,50.53) ; U1.A2 v1(53.78,47.23)
  L08_SIG2 w0.091: v1(53.78,47.23) 53.39,46.84 50.19,46.84 49.34,47.69 49.1,47.69 48.72,48.07 48.72,48.45 48.45,48.72 47.56,48.72 47.37,48.91 47.37,49.22 47.45,49.3 47.73,49.3 47.81,49.38 47.81,49.5 47.73,49.58 47.45,49.58 47.37,49.66 47.37,49.77 47.45,49.85 47.73,49.85 47.81,49.93 47.81,50.05 47.73,50.13 47.45,50.13 47.37,50.21 v1(47.37,50.53)
  BOTTOM w0.147: v1(47.37,50.53) 47.37,50.77 RA5.5
SOC_MMC0_SDCD: length 15.4
  TOP w0.147: v1(45.59,50.53) 45.85,50.28 45.85,49.84 ; U1.A5 v1(56.18,47.23)
  L08_SIG2 w0.091: v1(56.18,47.23) 56.18,47.6 55.7,48.08 55.41,48.08 54.79,48.7 54,48.7 53.84,48.86 53.84,49.12 52.77,50.19 52.42,50.19 52.17,49.94 51.82,49.94 51.63,50.13 50.85,50.13 50.6,50.38 50.6,50.69 50.06,51.23 46.29,51.23 v1(45.59,50.53)
  BOTTOM w0.147: v1(45.59,50.53) 45.8,50.74 RA5.7
SOC_MMC0_WP: length 17.7
  TOP w0.147: RA4.8 44.7,50.35 v1(44.7,50.53) ; U1.C6 v1(56.98,45.63)
  L08_SIG2 w0.091: v1(56.98,45.63) 56.59,45.24 52.75,45.24 52.21,45.79 52.21,46.18 51.97,46.42 49.92,46.42 48.53,47.82 46.51,47.82 44.7,49.63 v1(44.7,50.53)
  BOTTOM w0.147: RA5.8 44.7,50.74 v1(44.7,50.53)
SOC_OSPI0_CLK: length 18.8
  TOP w0.147: v1(47.44,38.52) 48,37.96 48.89,37.96 49.2,38.27 R87.1
  L03_SIG1 w0.091: v1(47.44,38.52) 47.74,38.52 48.25,39.04 48.46,39.04 49,39.57 49,41.18 48.78,41.4 48.36,41.4 46.22,43.54 46.22,43.77 46.3,43.85 46.42,43.85 47.93,42.34 48.11,42.34 48.19,42.42 48.19,42.53 46.64,44.08 45.66,44.08 45.4,43.82 v1(43.67,43.82)
  BOTTOM w0.147: U80.2 v1(43.67,43.82)
SOC_OSPI0_CSN0: length 3.5
  TOP w0.147: U1.P1 52.33,36.43 51.63,37.13 R98.2
SOC_OSPI0_CSN1: length 5.9
  TOP w0.147: U1.R3 v1(54.58,35.23)
  BOTTOM w0.114: 53.54,35.63 54.01,35.63
  BOTTOM w0.147: 54.01,35.63 54.18,35.63 v1(54.58,35.23) ; R99.2 50.18,33.89 50.94,34.66 52.07,34.66 53.04,35.63 53.54,35.63
SOC_OSPI0_D0: length 17.6
  L03_SIG1 w0.091: v1(45.06,35.68) 44.62,36.12 43.61,36.12 43.11,36.62 43.11,40.09 43.52,40.5 44.06,40.5 44.2,40.36 44.34,40.36 44.52,40.54 44.52,40.71 44.27,40.95 44.27,42.29 v1(44.79,42.82)
  BOTTOM w0.147: v1(45.06,35.68) 45.56,35.17 46.28,35.17 46.62,35.51 47.6,35.51 47.8,35.71 R119.1 48.38,36.13 48.51,36.26 R90.1 ; v1(44.79,42.82) 44.29,43.32 U80.3
SOC_OSPI0_D1: length 17.1
  L03_SIG1 w0.091: v1(43.67,42.82) 44.24,43.39 44.97,43.39 45.22,43.14 45.22,42.55 45.57,42.21 45.57,41.54 45.38,41.35 44.97,41.35 44.89,41.27 44.89,41.16 44.97,41.07 45.38,41.07 45.46,40.99 45.46,40.85 45.06,40.45 45.06,40.34 45.14,40.26 45.26,40.26 45.65,40.65 45.77,40.65 45.85,40.57 45.85,40.46 45.45,40.06 45.45,39.95 45.53,39.87 45.64,39.87 46.04,40.26 46.15,40.26 46.23,40.18 46.23,40.07 45.84,39.67 45.84,39.56 45.92,39.48 46.03,39.48 46.82,40.27 47.18,40.27 47.44,40.01 v1(47.44,39.67)
  BOTTOM w0.147: v1(47.44,39.67) 48.01,39.09 48.01,38.22 47.8,38 R122.1 R91.1 ; U80.4 v1(43.67,42.82)
SOC_OSPI0_D2: length 15.6
  L03_SIG1 w0.091: v1(48.51,40.83) 48.23,41.11 47.99,41.11 47.48,40.6 47.37,40.6 47.29,40.68 47.29,40.79 47.86,41.37 47.86,41.48 47.78,41.56 47.67,41.56 47.09,40.99 46.98,40.99 46.9,41.07 46.9,41.18 47.47,41.75 47.47,41.87 47.39,41.95 47.28,41.95 46.7,41.38 46.59,41.38 46.51,41.46 46.51,41.57 47.08,42.14 47.08,42.26 47,42.34 46.89,42.34 46.14,41.59 46.02,41.59 45.94,41.67 45.94,41.78 46.7,42.53 46.7,42.67 46.18,43.19 45.95,43.19 45.81,43.05 v1(45.81,42.8)
  BOTTOM w0.147: R92.1 v1(48.51,40.83) ; v1(45.81,42.8) 45.33,42.32 U80.5
SOC_OSPI0_D3: length 17.3
  L03_SIG1 w0.091: v1(43.67,41.82) 43.22,41.82 43.11,41.94 43.11,43.04 42.97,43.18 42.79,43.18 42.67,43.06 42.67,36.4 43.82,35.25 46.44,35.25 46.65,35.47 48.08,35.47 v1(48.51,35.04)
  BOTTOM w0.147: U80.6 v1(43.67,41.82) ; R93.1 48.58,35.12 v1(48.51,35.04)
SOC_OSPI0_D4: length 10.8
  TOP w0.147: v1(44.83,38.82) 45.15,39.14 45.34,39.14 45.58,38.91 45.58,38.14 45.71,38.01 45.89,38.01 46.02,38.14 46.02,39.18 46.15,39.31 46.33,39.31 46.46,39.18 46.46,38.27 46.59,38.14 46.77,38.14 46.9,38.27 46.9,38.82 47.16,39.08 48.88,39.08 R94.1
  BOTTOM w0.147: v1(44.83,38.82) 44.33,39.32 U80.11
SOC_OSPI0_D5: length 8.8
  TOP w0.147: R95.1 48.91,41.39 47.64,41.39 47.52,41.26 47.52,40.86 47.39,40.73 47.2,40.73 47.07,40.86 47.07,41.26 46.94,41.39 46.22,41.39 v1(43.65,38.82)
  BOTTOM w0.147: U80.12 v1(43.65,38.82)
SOC_OSPI0_D6: length 10.1
  TOP w0.147: R96.1 48.91,40.25 46.71,40.25 46.58,40.12 46.58,39.82 46.45,39.7 46.26,39.7 46.13,39.82 46.13,40.12 46.01,40.25 45.61,40.25 44.32,38.95 44.32,38.34 v1(44.83,37.83)
  BOTTOM w0.147: U80.13 44.34,38.32 v1(44.83,37.83)
SOC_OSPI0_D7: length 10.1
  TOP w0.147: R97.1 48.91,42.53 46.88,42.53 43.89,39.54 43.58,39.54 43.2,39.16 43.2,38.29 v1(43.67,37.82)
  BOTTOM w0.147: U80.14 v1(43.67,37.82)
SOC_OSPI0_DQS: length 18.3
  L03_SIG1 w0.091: v1(44.67,36.82) 46.39,36.82 46.57,36.63 46.57,35.93 46.75,35.75 48.37,35.75 48.55,35.93 48.55,36.49 48.43,36.61 47.19,36.61 47.11,36.69 47.11,36.8 47.19,36.88 48.43,36.88 48.51,36.96 48.51,37.08 48.43,37.16 47.19,37.16 47.11,37.24 47.11,37.35 47.19,37.43 48.43,37.43 48.51,37.51 48.51,37.63 48.43,37.71 47.19,37.71 47.11,37.79 47.11,37.9 47.19,37.98 48.43,37.98 48.51,38.06 v1(48.51,38.54)
  BOTTOM w0.147: v1(44.67,36.82) 44.17,37.32 U80.15 ; R118.1 v1(48.51,38.54)
SOC_OSPI0_LBCLK: length 9.1
  L03_SIG1 w0.091: v1(43.67,36.82) 43.67,37.15 44,37.48 44.44,37.48 44.64,37.28 45.42,37.28 45.57,37.43 45.57,37.89 45.74,38.06 46.13,38.06 46.39,37.8 46.66,37.8 46.78,37.91 46.78,38.68 47.09,39 47.82,39 v1(48.51,39.69)
  BOTTOM w0.147: R117.1 v1(48.51,39.69) ; U80.16 v1(43.67,36.82)
SOC_SPI1_CLK: length 77.1
  TOP w0.147: R140.1 v1(60.2,51.73) ; U8.4 R43.2 61.91,9 62.55,8.36 v1(63.01,8.36)
  L08_SIG2 w0.091: v1(63.01,8.36) 62.61,7.95 62.61,7.4 62.86,7.15 63.82,7.15 66.75,10.07 66.75,12.37 69.14,14.76 74.31,14.76 76.96,17.41 76.96,23.37 80.42,26.83 80.42,27.62 80,28.04 80,28.54 78.43,30.12 78.43,30.71 77.97,31.17 77.97,34.49 76.89,35.56 76.89,38.22 76.17,38.95 76.17,42.62 75.67,43.11 75.67,44 72.47,47.2 72.47,48.02 71.12,49.38 69.6,49.38 68.6,50.38 67.85,50.38 67.17,51.06 67.17,51.58 66.63,52.12 64.94,52.12 63.67,53.39 61.86,53.39 v1(60.2,51.73)
SOC_SPI1_CS0: length 50.4
  TOP w0.147: U8.12 R46.2 v1(61.84,19.3)
  L03_SIG1 w0.091: v1(61.84,19.3) 61.84,19.67 62.05,19.88 62.05,22.5 62.34,22.79 63.61,22.79 63.61,22.79 64.68,22.79 65.36,23.48 65.36,24.5 67.2,26.34 67.2,30.67 69.06,32.53 69.06,34.1 68.32,34.84 66.42,34.84 66.17,35.09 66.17,36.19 65.92,36.44 62.36,36.44 62.17,36.63 62.17,37.06 61.99,37.24 60.81,37.24 60.59,37.46 60.59,39.94 60.37,40.16 60.37,50.43 59.69,51.12 59.69,52.39 v1(59.37,52.7)
  BOTTOM w0.147: R144.1 60.21,50.88 59.69,51.4 59.69,52.38 v1(59.37,52.7)
SOC_SPI1_D0: length 59.5
  TOP w0.147: R44.2 65.95,12.07 66.51,12.63 v1(66.51,13.16) 64.18,13.16 63.86,12.85 U8.7
  L08_SIG2 w0.091: v1(66.51,13.16) 66.99,13.65 66.99,14.05 69.89,16.94 74.98,16.94 75.91,17.87 75.91,33.69 74.93,34.68 74.93,37.95 74.2,38.68 74.2,41.99 69.65,46.54 69.65,47.64 68.04,49.25 67.41,49.25 66.68,49.98 64.79,49.98 63.33,51.45 v1(63.33,52.31)
  BOTTOM w0.147: R141.1 62.73,50.88 63.33,51.49 v1(63.33,52.31)
SOC_SPI1_D1: length 37.7
  TOP w0.147: U1.D9 v1(59.38,44.83) ; v1(65.27,19.3) R45.2 U8.9
  L08_SIG2 w0.091: v1(65.27,19.3) 64.73,19.85 64.73,22.03 66.42,23.72 66.42,26.29 67.15,27.02 67.15,31.89 67.78,32.52 67.78,39.38 67.54,39.62 60.6,39.62 60.5,39.72 60.15,40.07 60.15,40.07 59.79,40.43 59.79,44.39 59.64,44.53 59.64,44.57 v1(59.38,44.83)
SOC_TA_I2C2_SCL: length 35.8
  L03_SIG1 w0.091: v1(63.11,98.54) 61.06,96.49 50.29,96.49 46.94,93.13 46.94,78.3 v1(46.1,77.46)
  BOTTOM w0.147: R302.1 v1(63.11,98.54) ; R310.2 v1(46.1,77.46)
SOC_TA_I2C2_SDA: length 44.6
  L08_SIG2 w0.091: v1(65.15,98.54) 65.57,98.97 66.34,98.97 66.59,98.72 66.59,97.58 66.15,97.15 66.15,90.87 64.71,89.42 64.71,78.74 63.61,77.65 61.93,77.65 60.53,79.05 50.44,79.05 49.61,78.22 47.92,78.22 v1(45.97,76.26)
  BOTTOM w0.147: R311.2 v1(45.97,76.26) ; R304.1 v1(65.15,98.54)
SOC_TCK: length 36.1
  TOP w0.147: U30.12 v1(36.06,61.09) ; U1.B3 v1(54.58,46.43)
  L03_SIG1 w0.091: v1(54.58,46.43) 54.97,46.82 54.97,47.4 53.54,48.83 53.54,51.72 49.71,55.54 36.61,55.54 33.99,58.17 33.99,60.35 34.73,61.09 v1(36.06,61.09)
  BOTTOM w0.147: v1(36.06,61.09) 36.1,61.06 TP52.1
SOC_TDI: length 38.6
  TOP w0.147: v1(34.41,59.14) 33.76,59.79 U30.7 ; U1.C5 v1(56.18,45.63)
  L03_SIG1 w0.091: v1(56.18,45.63) 55.79,46.02 55.79,47.47 55.21,48.04 54.64,48.04 53.72,48.96 53.72,51.79 48.39,57.12 36.43,57.12 v1(34.41,59.14)
  BOTTOM w0.114: 56.58,47.49 56.58,46.03 v1(56.18,45.63)
  BOTTOM w0.147: 56.58,47.49 56.58,48.04 57.19,48.65 TP53.1
SOC_TDO: length 32.9
  TOP w0.147: U30.4 34.21,61.74 35.13,60.83 35.13,58.48 36.22,57.39 TP54.1 43.7,56.76 44.39,56.76 v1(45.09,56.05)
  L08_SIG2 w0.091: v1(45.09,56.05) 44.81,55.78 44.81,52.74 45.61,51.95 53.08,51.95 53.79,52.65 54.92,52.65 v1(55.39,52.18)
  BOTTOM w0.147: v1(55.39,52.18) 55.37,52.16 R177.1
SOC_TDO_R: length 5.5
  TOP w0.147: U1.C4 v1(55.38,45.63)
  BOTTOM w0.114: 54.98,47.49 54.98,46.03
  BOTTOM w0.147: R177.2 55.37,49.69 54.98,49.31 54.98,47.49 ; 54.98,46.03 v1(55.38,45.63)
SOC_TMS: length 33.1
  TOP w0.147: v1(36.06,59.14) U30.9 ; U1.D5 v1(56.18,44.83)
  L03_SIG1 w0.091: v1(36.06,59.14) 37.73,57.47 48.3,57.47 53.91,51.87 53.91,49.04 54.64,48.3 55.66,48.3 56.57,47.39 56.57,45.22 v1(56.18,44.83)
  BOTTOM w0.147: v1(36.06,59.14) 36.18,59.02 TP55.1
SOC_XDS_I2C2_SCL: length 20.9
  TOP w0.147: R312.2 v1(39.03,78.27)
  L03_SIG1 w0.091: v1(39.03,78.27) 38.17,79.14 38.17,84.21 34.63,87.74 28.66,87.74 v1(27.68,88.72)
  BOTTOM w0.147: v1(27.68,88.72) 27.94,88.46 U52.82
SOC_XDS_I2C2_SDA: length 22.6
  TOP w0.147: R313.2 v1(39.11,76.06)
  L03_SIG1 w0.091: v1(28.57,88.72) 29.36,87.93 34.71,87.93 38.35,84.29 38.35,79.87 39.46,78.76 39.46,76.41 v1(39.11,76.06)
  BOTTOM w0.147: U52.81 28.34,88.49 v1(28.57,88.72)
SPI1_MUX_OE#: length 2
  TOP w0.147: U8.15 60.61,18.84 61.08,19.3 R50.1
SPI1_MUX_SEL: length 146.3
  TOP w0.147: v1(60.83,9.92) R49.1 U8.1
  L08_SIG2 w0.091: v1(23.79,19.02) 18.39,19.02 15.35,22.05 15.35,31.84 17.39,33.88 17.39,37.06 15.32,39.14 15.32,53.46 19.92,58.06 19.92,59.39 26.48,65.94 28.19,65.94 30.11,67.87 45.21,67.87 45.44,68.09 47.82,68.09 49.81,70.08 53,70.08 53.74,69.34 53.74,68.88 54.89,67.73 55.97,67.73 56.96,66.75 56.96,66.2 57.51,65.65 v1(57.88,65.65)
  BOTTOM w0.147: v1(57.88,65.65) 57.56,65.97 57.27,65.97 56.96,66.29 U60.11 ; v1(60.83,9.92) 60.07,10.68 60.07,14.98 56.48,18.56 52.82,18.56 49.55,21.83 36.85,21.83 35.52,20.51 25.68,20.51 24.52,19.34 24.51,19.34 24.11,19.34 v1(23.79,19.02)
SW_PB_INTN: length 7.8
  TOP w0.147: Q10.2 59.62,94.18 59.65,94.2 v1(59.65,95.49) SW11.2
  BOTTOM w0.147: R542.2 57.02,93.08 56.79,93.31 56.79,94.12 57.42,94.75 58.91,94.75 v1(59.65,95.49)
SW_PB_PORZ: length 12.4
  TOP w0.147: v1(52.27,89.09) 53.15,89.97 Q9.2 53.15,95.37 52.69,95.83 SW10.2
  BOTTOM w0.147: R541.2 55.12,88.73 52.62,88.73 v1(52.27,89.09)
SW_PB_RESETZ: length 24.4
  TOP w0.147: R543.2 50.44,95.5 50.44,98.27 51.8,99.63 63.91,99.63 64.64,98.9 64.64,97.37 65.18,96.84 SW12.2 Q11.2
SYS_BOOTMODE0: length 8.6
  TOP w0.147: R323.2 SW6.1 v1(62.86,84.71) 61.97,83.81 U47.2
  BOTTOM w0.147: U48.6 63.77,86.3 63.53,86.06 63.53,85.38 v1(62.86,84.71)
SYS_BOOTMODE1: length 9.3
  TOP w0.147: R324.2 SW6.2 63.18,85.98 63.17,85.97 v1(62.86,85.97) 61.47,84.57 U47.3
  BOTTOM w0.147: U48.7 63.59,86.7 v1(62.86,85.97)
SYS_BOOTMODE2: length 10.5
  TOP w0.147: U47.4 60.97,84.95 62.23,86.21 62.23,86.61 v1(62.86,87.25) SW6.3 R325.2
  BOTTOM w0.147: U48.8 63.46,87.1 63.31,87.25 v1(62.86,87.25)
SYS_BOOTMODE3: length 14.2
  TOP w0.147: R326.2 SW6.4 v1(62.86,88.52) 60.25,85.9 60.25,81.93 60.27,81.91 U47.5
  BOTTOM w0.147: U48.9 64.95,87.94 64.37,88.52 v1(62.86,88.52)
SYSBOOT_BUF_ENZ: length 6.7
  BOTTOM w0.147: R328.1 64.8,94.77 66.04,96 67.44,96 67.93,96.48 U49.2
TA_GPIO1: length 33.2
  TOP w0.147: v1(58.84,98.49) 59.52,99.17 60.32,99.17 60.63,98.87 60.63,98.03 60.88,97.78 60.88,95.82 61.55,95.15 Q10.1 ; R371.2 v1(45.59,105.27)
  L08_SIG2 w0.091: v1(58.84,98.49) 59.22,98.11 60.24,98.11 60.49,98.36 60.49,98.74 56.62,102.61 44.64,102.61 44.19,103.06 44.19,103.87 v1(45.59,105.27)
  BOTTOM w0.147: R298.1 v1(58.84,98.49) 58.84,97.89 58.92,97.81 R291.1
TA_GPIO1_XDS: length 22.4
  TOP w0.147: v1(31.56,105.9) 31.57,105.9 R365.2 U57.2
  L08_SIG2 w0.091: v1(31.14,88.72) 31.41,88.98 31.41,89.23 32.55,90.36 32.55,102.99 31.14,104.4 31.14,105.48 v1(31.56,105.9)
  BOTTOM w0.147: U52.74 v1(31.14,88.72)
TA_GPIO2: length 74.7
  L08_SIG2 w0.091: v1(19.81,72.56) 27.81,72.56 28.71,71.65 42.89,71.65 45.51,74.26 45.51,97.02 44.45,98.08 44.45,101.05 45.71,102.31 56.3,102.31 v1(60.07,98.54)
  BOTTOM w0.147: R299.1 v1(60.07,98.54) R290.1 ; R378.2 v1(19.81,72.56)
TA_GPIO2_XDS: length 19.5
  L08_SIG2 w0.091: v1(31.54,86.1) 31.54,85.52 27.55,81.52 18.3,81.52 v1(17.92,81.14)
  BOTTOM w0.147: U58.2 R377.2 v1(17.92,81.14) ; U52.73 v1(31.54,86.1)
TA_GPIO3: length 43.8
  TOP w0.147: R372.2 v1(45.59,104.13)
  L03_SIG1 w0.091: v1(61.08,98.54) 64.26,101.71 J12.1
  L08_SIG2 w0.091: v1(45.59,104.13) 57.4,104.13 59.82,101.71 J12.1
  BOTTOM w0.147: J12.1 68.14,101.71 67.3,100.87 67.3,98.46 66.98,98.14 U49.1 ; R289.1 61.21,97.81 61.08,97.93 v1(61.08,98.54) R300.1
TA_GPIO3_XDS: length 20.7
  TOP w0.147: v1(31.57,104.57) R366.2 U57.3
  L08_SIG2 w0.091: v1(31.57,104.57) 33.02,103.12 33.02,90.06 v1(32.65,89.69)
  BOTTOM w0.147: v1(32.65,89.69) 31.94,88.98 U52.72
TA_GPIO4: length 39.2
  TOP w0.147: R373.2 v1(44.87,103.45) ; U47.1 v1(62.47,83.03)
  L08_SIG2 w0.091: v1(62.47,83.03) 62.08,83.42 62.08,90.48 62.9,91.3 62.9,97.74 v1(62.1,98.54) 61.44,99.2 60.97,99.2 56.72,103.45 v1(44.87,103.45)
  BOTTOM w0.147: R301.1 v1(62.1,98.54) 62.1,98.08 62.35,97.83 R288.1
TA_GPIO4_XDS: length 21
  TOP w0.147: R367.2 U57.4 v1(35.8,102.72)
  L08_SIG2 w0.091: v1(32.69,88.69) 33.62,89.62 33.62,100.54 v1(35.8,102.72)
  BOTTOM w0.147: U52.71 32.34,88.34 v1(32.69,88.69)
TA_PORZN: length 21.9
  TOP w0.147: R374.2 v1(44.87,100.87) ; v1(56.88,98.54) 56.38,98.04 56.38,95.58 55.05,94.24 Q9.1
  L08_SIG2 w0.091: v1(56.88,98.54) 53.49,101.93 45.93,101.93 v1(44.87,100.87)
  BOTTOM w0.147: R293.1 56.64,97.84 56.88,98.08 v1(56.88,98.54) R296.1
TA_PORZN_XDS: length 19.9
  TOP w0.147: U57.5 R368.2 v1(31.57,100.86)
  L08_SIG2 w0.091: v1(31.57,100.86) 30.84,100.14 30.84,91.5 29.12,89.78 29.12,86.94 v1(29.94,86.12)
  BOTTOM w0.147: U52.77 v1(29.94,86.12)
TA_POWERDOWNZ: length 169.5
  TOP w0.147: R20.1 86,28.53 v1(85.85,28.38) ; R376.2 v1(44.87,98.33)
  L03_SIG1 w0.091: v1(104.07,98.36) 104.07,104.16 100.32,107.92 81.42,107.92 75.41,101.9 71.28,101.9 70.36,102.83 68.27,102.83 67.49,102.05 59.38,102.05 v1(55.88,98.54)
  L08_SIG2 w0.091: v1(44.87,98.33) 45.63,98.33 46.49,99.18 55.23,99.18 v1(55.88,98.54) ; v1(104.07,98.36) 104.07,97.45 105.48,96.05 105.48,83.57 100.76,78.86 97.87,78.86 96.7,77.68 92.49,77.68 92.09,78.07 90.97,78.07 90.47,77.57 90.47,76.51 94.56,72.41 94.56,66.27 95.32,65.51 95.32,40.69 93.89,39.26 93.89,38.13 94.2,37.83 95.19,37.83 v1(95.72,37.31)
  BOTTOM w0.147: v1(95.72,37.31) 95.24,37.78 91.79,37.78 91.16,37.15 90.09,37.15 87.42,34.48 87.42,31.58 85.85,30.01 v1(85.85,28.38) ; R295.1 v1(55.88,98.54) 55.41,98.07 R468.1
TA_POWERDOWNZ_XDS: length 14.2
  TOP w0.147: v1(31.57,98.32) R370.2 U57.7
  L08_SIG2 w0.091: v1(29.54,88.72) 31.57,90.74 v1(31.57,98.32)
  BOTTOM w0.147: U52.78 v1(29.54,88.72)
TA_RESETZ: length 33.1
  TOP w0.147: Q11.1 63.58,92.64 61.7,90.75 59.98,90.75 58.38,92.36 58.38,98.01 v1(57.85,98.54) ; R375.2 v1(44.87,99.6)
  L08_SIG2 w0.091: v1(44.87,99.6) 45.58,100.31 54.71,100.31 56.3,98.72 56.3,98.52 56.71,98.11 57.42,98.11 v1(57.85,98.54)
  BOTTOM w0.147: R297.1 v1(57.85,98.54) 57.85,98.08 57.78,98.02 R292.1
TA_RESETZ_XDS: length 15.5
  TOP w0.147: v1(31.57,99.59) R369.2 U57.6
  L08_SIG2 w0.091: v1(31.11,89.65) 31.99,90.53 31.99,99.17 v1(31.57,99.59)
  BOTTOM w0.147: U52.76 30.34,88.88 v1(31.11,89.65)
TCAN_WAKE: length 7.3
  TOP w0.147: U29.9 v1(19.9,24.41)
  BOTTOM w0.147: R31.2 19.9,18.48 v1(19.9,24.41)
TM4C129_RST#: length 7.6
  BOTTOM w0.147: R355.1 R353.2 34.16,83.3 33.9,83.55 TP73.1 32.51,86.19 32.74,86.43 U52.70
TM4C129_TCK: length 3.1
  BOTTOM w0.147: TP68.1 18.71,90.59 19.19,90.11 U52.100
TM4C129_TDI: length 5.5
  BOTTOM w0.147: TP70.1 16.67,89.31 U52.98
TM4C129_TDO: length 3.1
  BOTTOM w0.147: TP71.1 18.74,88.46 19.2,88.91 U52.97
TM4C129_TMS: length 5.4
  BOTTOM w0.147: U52.99 16.6,89.71 TP69.1
TMP411_ALERT: length 1.7
  BOTTOM w0.147: R160.2 U27.6
TMP411_THERM: length 1.8
  BOTTOM w0.147: R161.2 U27.4
TPS2121_CP2: length 7.6
  TOP w0.147: v1(95.52,20.31) 96.02,19.81 U4.3
  BOTTOM w0.147: v1(95.52,20.31) 97.34,20.31 R15.1 R11.2
TPS2121_OV1: length 6.4
  TOP w0.147: U4.5 95.02,19.81 v1(94.52,20.31)
  BOTTOM w0.147: v1(94.52,20.31) 95.28,21.07 96.06,21.07 96.53,21.54 R12.2 R16.1
TPS2121_OV2: length 6.9
  TOP w0.147: U4.4 v1(95.52,19.29)
  BOTTOM w0.147: R10.2 R14.1 95.85,19.63 v1(95.52,19.29)
TPS2121_PR1: length 5.1
  TOP w0.147: U4.6 v1(94.52,19.29)
  BOTTOM w0.147: v1(94.52,19.29) 94.52,19.61 94,20.13 R17.1 R13.2
TPS2296_EN: length 8.5
  TOP w0.147: U2.4 LD1.1 103.78,15.39 103.44,15.74 v1(101.47,15.74) ; U3.3 v1(103.25,18.55)
  BOTTOM w0.147: v1(101.47,15.74) 102.11,16.38 102.11,17.42 v1(103.25,18.55)
TUSB_OUT1: length 3.2
  TOP w0.147: U2.2 103.28,11.6 v1(103.03,11.35)
  BOTTOM w0.147: v1(103.03,11.35) R4.2 102,11.67 U17.7
TUSB_OUT2: length 5.5
  TOP w0.147: v1(100.2,11.35) 102,11.35 102.78,12.13 U2.1
  BOTTOM w0.147: v1(100.2,11.35) R3.2 101.08,11.35 101.6,11.86 U17.8
UART0_RXD: length 57.5
  TOP w0.147: U1.A7 v1(57.78,47.23)
  L03_SIG1 w0.091: v1(57.78,47.23) 57.78,48.33 57.41,48.7 57.41,49.81 56.26,50.97 56.26,53.16 51.33,58.08 51.33,68.27 54.58,71.51 56.29,71.51 57.74,72.97 57.74,75.72 55.63,77.83 55.63,87.89 50.77,92.76 v1(50.77,93.61)
  BOTTOM w0.147: v1(50.77,93.61) 50.78,93.62 R344.1
UART0_TXD: length 59.4
  TOP w0.147: U1.A6 v1(56.98,47.23)
  L03_SIG1 w0.091: v1(49.14,93.46) 49.14,93.13 49.75,92.52 50.59,92.52 55.35,87.76 55.35,77.73 57.46,75.62 57.46,73.17 56.06,71.78 52.57,71.78 51,70.21 51,58.05 55.27,53.79 55.27,52.82 55.48,52.61 55.72,52.61 55.81,52.52 55.81,50.06 56.21,49.67 56.21,48.38 56.98,47.6 v1(56.98,47.23)
  BOTTOM w0.147: U54.3 48.89,93.71 v1(49.14,93.46)
UART2_MUX_SEL: length 12.7
  TOP w0.147: U20.1 45.87,66.21 46.34,66.68 R67.1 R62.2 50.69,66.68 51.08,67.07 55.92,67.07 v1(56.46,66.54)
  BOTTOM w0.147: U60.12 v1(56.46,66.54)
UART2_RXD_HSEC: length 111.4
  TOP w0.147: v1(105.64,4.56) 105.18,4.56 104.84,4.21 J15.161 ; v1(49.11,62.16) 49.11,62.95 47.75,64.31 U20.3
  L08_SIG2 w0.091: v1(105.64,4.56) 106.38,3.82 108.84,3.82 109.36,4.33 109.36,7.96 107.69,9.63 105.52,9.63 105.13,10.02 103.6,10.02 102.33,11.29 102.33,11.73 98.57,15.5 96.51,15.5 95,17.01 95,23.07 85.46,32.61 85.46,39.91 82.56,42.81 82.56,45.24 80.41,47.4 80.41,51.17 77.79,53.79 71.71,53.79 71.1,54.4 69.44,54.4 68.98,54.86 68.98,55.21 68.47,55.73 67.26,55.73 66.09,56.9 59.33,56.9 58.42,55.99 53.83,55.99 49.11,60.71 v1(49.11,62.16)
UART2_TXD_HSEC: length 111.5
  TOP w0.147: U20.6 47.15,62.36 v1(47.41,62.09)
  L08_SIG2 w0.091: v1(47.41,62.09) 45.67,60.35 45.67,55.89 45.1,55.32 45.1,52.75 45.66,52.18 51.72,52.18 53.05,53.51 58.41,53.51 59.34,54.44 65.03,54.44 66.19,53.28 67.19,53.28 67.95,52.52 69.89,52.52 70.92,51.48 73.31,51.48 74.93,49.86 76.68,49.86 77.94,48.6 77.94,40.42 79.54,38.82 79.54,31.52 82.98,28.08 82.98,17.63 85.31,15.3 92.5,15.3 98.74,9.06 98.74,8.55 99.14,8.14 101.52,8.14 103.07,6.59 103.07,6.17 103.66,5.58 v1(104.04,5.58)
  BOTTOM w0.147: v1(104.04,5.58) 104.67,4.94 104.67,4.27 104.84,4.1 J15.162
USB_XDS110_ID: length 20.7
  TOP w0.147: J13.4 14.74,94.33 v1(15.11,93.97)
  L08_SIG2 w0.091: v1(22.47,83.05) 22.47,86.6 v1(15.11,93.97)
  BOTTOM w0.147: R338.2 v1(22.47,83.05) ; v1(15.11,93.97) 15.11,93.59 14.73,93.21 13.33,93.21 13.16,93.38 U53.4
USD_LS_EN: length 2
  TOP w0.147: U23.3 14.06,53.84 14.06,53.84 U22.4
USER_LED0: length 10.5
  TOP w0.147: R146.2 53.88,59.46 53.55,59.79 49.81,59.79 48.01,61.58 48.01,62.35 47.35,63.01 U20.5
USER_LED1: length 13.1
  TOP w0.147: R147.2 47.93,55.15 46.07,53.29 46.07,52.7 44.02,50.65 44.02,47.89 44.55,47.36 R3877.2
VLIN: length 9.6
  TOP w0.381: D6.2 C236.1 SW4.2 ; D6.2 J10.1 ; D6.2 U45.7
VMAIN: length 19.9
  TOP w0.254: U5.9 88.55,26.61 C19.1
  TOP w0.381: R433.1 v1(79.2,28.28) ; v1(98.18,88.97) 97.66,88.45 TP80.1 ; R137.1 58.64,63.47 57.73,62.56 57.73,57.8 57.19,57.27 R138.1 ; U4.1 97.34,16.94 C12.2
  BOTTOM w0.254: U14.7 99.31,87.21 98.69,87.83
  BOTTOM w0.305: 53.58,78.85 53.94,79.21 53.94,79.39 ; 53.94,79.39 54.37,78.96 ; 53.94,79.39 U10.2
  BOTTOM w0.381: v1(53.97,28.18) 53.97,28.75 54.34,29.13 R201.1
  vias: v1(53.97,77.58) v1(54.86,77.58) v1(83.9,19.7) v1(83.9,18.94) v1(84.5,17.34) v1(85.52,17.31) v1(90.06,17.64) v1(90.19,16.65) v1(90.19,15.76) v1(91.08,17.54) v1(91.08,16.65) v1(91.08,15.76)
VMAIN_12V0: length 20.3
  TOP w0.254: U7.9 101.69,36.28 ; U7.7 100.69,36.27
  TOP w0.305: C348.2 17.69,24.25 18.03,23.91 U29.10
  TOP w0.381: C348.2 v1(17.07,23.54) ; U5.6 89.92,29.49 C376.1 ; R553.1 94.86,27.11 95.24,27.49 v1(95.24,28.03)
  L08_SIG2 w0.381: v1(95.24,28.03) 90.98,32.3 v1(90.75,32.3)
  BOTTOM w0.381: v1(17.07,23.54) 17.07,21.21 16.85,20.99 R175.1
  vias: v1(96.92,31.94) v1(96.92,31.05) v1(97.81,31.94) v1(97.81,31.05) v1(98.7,31.94) v1(98.7,31.05) v1(99.31,33.13) v1(100.27,34.48)
VMAIN_MON: length 3
  TOP w0.381: R433.2 R434.1 81.15,29.97 81.18,29.94 U79.2
VPP_1V7: length 55.8
  TOP w0.381: TP76.1 84.59,46.22 C346.1 85.77,45.17 R463.1 ; v1(47.62,35.04) 47.69,35.11 R63.1 47.82,35.68 47.83,35.69 49.12,35.69 R83.1
  L05_PWR1 w0.305: TP76.1 84.64,44.61 84.64,37.84 78.16,31.36 72.2,31.36 71.56,30.71 68.71,30.71 67.63,31.8 50.46,31.8 48,34.26 48,34.66 v1(47.62,35.04)
VPP_LDO_EN: length 72.1
  TOP w0.147: U66.4 90.84,44.92 90.91,44.85 R465.1 91.47,43.79 90.14,42.46 85.09,42.46 83.73,43.82 82.64,43.82 80.46,46 80.46,50.49 84.42,54.45 84.42,59.03 84.42,59.03 84.99,59.6 v1(86.31,59.6) ; v1(80.84,61.89) 80.84,63.28 78.32,65.8 75.36,65.8 74.84,66.32 74.84,66.78 74.34,67.28 63.28,67.28 62.52,66.52 62.52,64.36 v1(61.61,63.44)
  L08_SIG2 w0.091: v1(80.84,61.89) 84.02,61.89 v1(86.31,59.6)
  BOTTOM w0.147: v1(61.61,63.44) 60.65,64.4 57.66,64.4 55.96,66.1 U60.13
VPP_R: length 4.2
  TOP w0.305: U1.N3 v1(54.58,36.83)
  TOP w0.381: v1(51.32,36.67) 51.05,36.4 C101.1 50.39,35.98 R83.2 50.03,35.62 R467.2
  BOTTOM w0.381: TP86.1 51.73,37.09 v1(51.32,36.67)
VREG: length 2.1
  TOP w0.305: U7.40 101.69,46.02 v1(101.7,46.03)
  BOTTOM w0.381: C62.1 101.7,45.45 v1(101.7,46.03)
VREG_1P8_OUT: length 3.9
  TOP w0.305: v1(102.23,46.73) 102.23,46.2 102.24,46.19 102.24,45.81 102.19,45.77 U7.39
  BOTTOM w0.381: v1(102.23,46.73) 102.32,46.64 102.32,46.57 102.36,46.53 102.36,45.97 103.19,45.15 C61.1
VSYS_1V2: length 17.4
  TOP w0.254: 90.29,55.99 90.59,56.3 U9.3 90.58,56.75 90.55,56.72 90.13,56.72 89.78,56.38
  TOP w0.381: TP82.1 91.72,62.62 v1(90.58,61.48) 90.58,61.08 R52.1
  L06_PWR2 w0.305: v1(85.09,53.2) 85.59,53.71 87.67,53.71 90.58,56.62 v1(90.58,61.48)
  BOTTOM w0.381: R75.3 84.2,50.63 v1(84.2,51.42)
  vias: v1(83.31,52.31) v1(83.31,51.42) v1(84.2,53.2) v1(84.2,52.31) v1(85.09,54.09) v1(85.09,52.31) v1(85.09,51.42) v1(85.97,54.09) v1(85.97,53.2) v1(85.97,52.31)
VSYS_1V2_EN: length 4.8
  TOP w0.147: v1(93.14,56.3) 93.14,56.75 92.64,57.25 U9.5
  BOTTOM w0.147: v1(93.14,56.3) 93.14,55.36 92.99,55.21 R430.2 R51.2
VSYS_1V2_FB: length 2.8
  TOP w0.203: U9.9 90.33,59.13 90.27,59.2 R52.2 R56.2
VSYS_1V2_PG: length 98.8
  TOP w0.147: v1(67.43,77.46) 67.1,77.13 58.71,77.13 R76.2 ; U78.1 80.19,34.98 84.04,38.82 84.04,42.94 83.48,43.5 82.54,43.5 79.78,46.26 79.78,50.22 84.09,54.54 84.09,59.17 87.02,62.09 87.43,62.09 v1(88.11,61.41) 88.11,60.08 88.41,59.78 R59.2 89.06,59.78 89.63,59.21 89.63,57.94 89.82,57.75 U9.1
  L08_SIG2 w0.091: v1(88.11,61.41) 88.11,59.42 86.43,57.73 79.14,57.73 77.44,56.04 72.21,56.04 71.72,55.55 71.16,55.55 70.58,56.13 70.58,56.47 69.71,57.34 67.48,57.34 67.1,57.72 67.1,68.4 67.28,68.58 67.28,76.94 67.43,77.09 v1(67.43,77.46)
VSYS_1V2_SW: length 1.7
  TOP w0.254: 89.04,57.25 U9.2
  TOP w0.381: 88.77,57.52 89.04,57.25
VSYS_1V7_FB: length 2.8
  TOP w0.147: R464.1 R463.2 86.99,44.96 87.6,45.57 U66.2
VSYS_3V3_LDO1: length 282.8
  TOP w0.203: v1(73.02,59.89) 73.52,60.39 U87.30
  TOP w0.254: 103,50.87 v1(103,51.79)
  TOP w0.305: v1(79.01,64.39) U87.17 ; R1647.1 v1(25.55,25.62) ; U87.1 78.71,56.39 79.01,56.09 v1(79.01,55.89) ; U84.1 93.88,84.85 94.14,84.59 v1(94.14,84.34) ; U85.30 v1(89.06,101.84) ; 102.87,46.6 102.87,47.61 ; 102.87,46.6 103.19,46.27 U7.37 ; 102.87,46.6 102.87,46.47 102.69,46.3 U7.38 ; U29.5 23.12,23.91 23.2,23.99 C175.2 v1(23.84,24.75) ; U84.17 93.83,92.85 94.14,93.15 v1(94.14,93.35) ; v1(94.14,106.34) 94.14,106.14 93.83,105.84 U85.17 ; U84.30 v1(89.06,88.85) ; U85.1 v1(94.14,97.84)
  TOP w0.381: R40.1 110.72,55 v1(110.61,55.11) 109.79,55.92 108.89,55.92 107.82,54.85 103.37,54.85 ; U42.1 18.98,42.52 C233.1 18.98,44.6 18.92,44.66 FL6.1 C230.1 v1(15.74,45.9) ; R85.1 26.58,54.75 v1(26.58,54.75) ; R276.2 v1(16.23,36.18) ; R3858.1 48.29,94.89 49.92,96.53 v1(49.92,97.02) ; R184.1 v1(40.29,67.08) ; C373.1 81.8,105.84 v1(81.3,106.34) ; R3878.2 36.38,36.49 v1(36.44,36.56) ; C361.1 66.55,64.77 v1(66.18,64.39) ; R153.1 v1(56.7,51.73) ; R153.1 R152.1 57.84,54.4 59.03,55.59 R3842.1 v1(59.83,56.45) ; R153.1 R157.1 R156.1 ; U19.D1 v1(34.54,43.66) ; R471.1 v1(73.43,27.88) ; R3872.1 50.2,92.86 v1(50.01,93.05) ; v1(43.68,44.82) 43.54,44.68 C3744.1 ; R108.2 v1(25.81,40.66) ; U78.5 83.31,33.37 84.05,34.11 C340.1 R431.1 v1(84.89,35.37) ; U46.1 C240.1 v1(49.42,74.17) ; R200.1 94.07,42.89 v1(94.32,43.14) ; C374.1 86.67,101.96 v1(87.29,101.34) ; C178.1 v1(41.72,63.56) ; R217.2 v1(80.79,36.44) ; C189.1 v1(80.63,42.81) ; C189.1 U36.5 ; C189.1 79,42.81 78.06,43.76 v1(76.4,43.76) ; C3745.1 38.49,40.23 v1(38.4,40.32) ; v1(95.53,79.75) 96.53,79.75 99.21,82.43 R78.2 R80.1 ; C372.1 v1(81.3,97.84) ; R109.1 v1(37.08,41.1) ; R181.1 R180.1 v1(28.11,62.43) ; v1(31.23,49.51) C157.1 31.23,51.08 31.25,51.1 U18.8 ; v1(82.51,83.67) 82.86,84.02 C369.1 ; R1678.2 R1679.2 42.45,37.2 42.65,36.99 C3743.1 42.65,35.69 v1(42.68,35.66) ; J15.119 67.84,4.79 67.18,5.45 67.18,8.12 65.95,9.34 v1(65.95,10.4) 65.91,10.45 R44.1 ; R426.1 v1(58.81,107.41) ; R183.1 R182.1 v1(42.41,58.95) ; v1(59.12,19.3) C73.1 59.96,19.16 U8.16 ; v1(77.52,34.22) 77.75,33.99 R3832.1 ; R45.1 v1(65.27,20.28) ; R86.1 v1(41.65,51.93) ; U20.16 C86.1 53.35,65.97 v1(52.76,66.55) ; R3852.2 v1(96.56,101.34) ; v1(88.98,61.45) 89.02,61.41 R59.1 ; v1(74.45,27.88) 74.97,28.4 R470.1 ; C362.1 v1(71.25,60.39) ; v1(43.81,55.99) R84.1 R1668.2 ; U19.B4 v1(30.35,41.16) ; R263.2 v1(69.77,94.3) ; R429.1 v1(65.8,107.41) ; R43.1 v1(62.89,10.66) ; v1(96.23,87.51) 95.86,87.88 R3849.2 ; C371.1 86.63,89.01 v1(87.29,88.35) ; v1(50.02,67.5) 48.38,67.5 R62.1 ; v1(103.12,56.63) 103.43,56.32 R48.1 ; R46.1 v1(62.56,21.07) ; R1667.2 v1(26.81,58.43) ; R267.2 v1(68.59,90.14) ; U79.5 C341.1 v1(84.79,33.35) ; v1(23.89,41.5) R102.1 R104.2 R103.2 ; R425.1 v1(51.83,107.41) ; C360.1 v1(66.18,55.89) ; U19.E4 v1(30.35,45.16) ; v1(40.25,63.69) C177.1 U30.16 ; R466.1 v1(17.8,20.65) ; U42.4 v1(19.41,39.48) ; C370.1 v1(81.3,92.85)
  L05_PWR1 w0.381: v1(96.23,87.51) 95.82,87.92 94.95,87.92 ; v1(90.07,78.07) 90.07,79.83
  BOTTOM w0.203: C243.1 65.75,84.2 U48.2
  BOTTOM w0.254: v1(43.68,44.82) 43.18,44.32 U80.1 ; U82.30 v1(71.25,60.39) ; U81.10 C356.1 v1(71.03,31.36) ; v1(80.63,42.81) 79.88,42.07 C3746.1 79.13,42.07 78.4,41.33 U90.10 ; U76.8 54.9,94.5 C335.1 ; C277.1 58.06,74.57 57.59,74.1 57.59,73.27 57.46,73.14 U60.31 ; U60.27 v1(55.46,73.44) 54.69,74.21 C278.1 ; U80.17 v1(42.68,35.66) ; U80.30 v1(38.4,40.32)
  BOTTOM w0.305: U88.30 86.11,101.84 86.24,101.96 86.67,101.96 v1(87.29,101.34) ; v1(82.51,83.67) 82.51,84.15 82.14,84.52 U89.1 ; v1(66.18,55.89) 66.18,56.09 66.48,56.39 U82.1 ; U89.30 86.07,88.85 86.18,88.96 86.68,88.96 v1(87.29,88.35) ; v1(81.3,106.34) 81.8,105.84 C373.1 ; C370.1 v1(81.3,92.85) ; U82.17 v1(66.18,64.39) ; C372.1 v1(81.3,97.84)
  BOTTOM w0.381: C367.1 93.5,93.99 v1(94.14,93.35) ; C187.2 22.48,30.21 J6.10 ; v1(59.29,75.81) R395.2 58.67,75.05 58.51,75.21 C277.1 ; v1(56.13,94.6) 56.11,94.58 C335.1 ; C243.1 v1(66.92,83.79) ; C365.1 89.85,101.84 v1(89.06,101.84) ; C358.1 78.79,64.62 v1(79.01,64.39) ; R162.1 R159.1 R158.1 v1(50.02,67.5) ; R472.1 78.2,30.32 v1(77.8,30.72) ; R474.2 v1(75.16,30.61) ; R436.1 v1(75.39,33.45) 76.74,33.45 R3867.1 ; R154.1 R155.1 73.07,96.43 v1(73.51,96.87) 73.1,97.28 73.1,97.67 72.38,98.39 R265.2 ; R428.1 54.46,89.93 54.58,89.93 v1(54.61,89.95) ; v1(71.76,32.45) 71.95,32.65 R437.1 ; C359.1 73.77,60.64 v1(73.02,59.89) ; v1(112.6,91.12) U28.8 C173.1 ; R167.1 111.33,95.9 v1(110.98,96.25) ; U16.1 93.39,82.61 93.65,82.86 C98.1 v1(95.34,82.86) ; R427.1 v1(51.92,98.22) ; C161.1 34.46,43.58 v1(34.54,43.66) 35.11,43.66 35.15,43.62 R101.2 R107.2 ; U32.1 32.93,72.92 C179.2 v1(32.91,72.14) ; v1(30.35,45.16) 30.41,45.22 C163.1 C160.1 ; v1(49.92,97.02) C265.1 U54.1 ; R3864.2 79.58,88.37 79.98,87.96 v1(80.37,87.96) ; U26.16 40.57,72.21 40.53,72.25 C171.1 v1(39.86,72.87) ; C363.1 93.81,97.51 v1(94.14,97.84) ; R544.1 49.25,91.74 v1(49.25,91.5) ; R111.2 30.92,41.73 v1(30.35,41.16) 30.87,40.63 C162.1 C164.2 ; v1(31.23,49.51) C158.1 31.44,50.52 C159.2 ; R3843.2 64.76,60.87 v1(64.5,60.62) ; v1(94.14,84.34) 94.14,85.05 C366.1 ; C357.1 78.92,55.98 v1(79.01,55.89) ; v1(80.79,36.44) 82.75,38.4 82.75,41.59 81.52,42.81 v1(80.63,42.81) ; 67.24,11.69 FL7.1 v1(67.24,17.77) ; R120.2 v1(30.32,37.12) ; R3861.1 79.02,100.11 78.28,99.37 C222.1 ; R214.1 v1(90.07,78.07) ; R3866.1 v1(76.4,43.76) ; v1(93,52.75) 92.99,52.76 R430.1 ; R392.2 v1(52.15,76.16) ; R38.1 110.33,54.82 v1(110.61,55.11) ; R1381.2 v1(80.11,60.83) ; C368.1 89.85,88.85 v1(89.06,88.85) ; v1(108.99,47.1) 108.99,47.29 108.42,47.87 R41.1 ; v1(49.51,85.6) C181.2 U31.8 ; U21.5 C166.1 35.74,36.5 R121.2 v1(36.44,36.56) ; v1(48.47,41.98) 49.24,41.98 R3882.1 ; v1(94.14,106.34) 93.89,106.09 C364.1 ; v1(34.79,47.61) 34.78,47.63 R106.2 R100.2 R105.2 ; U39.5 C222.1 ; C222.1 77.26,99.98 v1(77.52,100.25) ; R473.1 v1(68.46,27.49)
  vias: v1(102.99,48.63)
VSYS_3V3_LDO2: length 104.5
  TOP w0.305: U7.11 102.69,36.29 102.74,36.24 102.74,35.89 103.04,35.59 103.04,35.38 C66.1
  TOP w0.381: R128.1 28.44,48.03 v1(28.44,48.88) ; TP10.1 103.98,31.2 v1(103.98,34.53) ; v1(23.49,48.76) R129.1 R130.1 R131.1 ; 12.06,57.28 v1(12.06,58.53) ; 12.06,57.28 12.21,57.28 13.06,58.13 v1(13.06,58.52) ; 12.06,57.28 12.14,57.2 U23.1 ; R125.2 v1(19.68,52.57) ; U22.5 C167.1 v1(12.31,50.66) R3835.1 ; R282.1 R285.2 26.17,66.27 v1(26.03,66.41) ; R127.1 27.7,49.96 R132.1 27.7,51.88 v1(27.39,52.18)
  L03_SIG1 w0.381: 104.88,36.44 105.85,37.41 108.5,37.41 110.42,39.33 110.42,51.8 111.68,53.05 111.68,53.72 111.05,54.35 109.02,54.35 108.46,54.92 103.71,54.92 99.6,59.03 99.6,59.67 v1(98.93,60.34)
  L06_PWR2 w0.381: v1(91.69,52.95) 91.69,53.67 98.36,60.34 v1(98.93,60.34)
  BOTTOM w0.203: v1(98.93,60.34) C90.1 97.68,60.34 96.96,59.62 U12.6 ; U13.2 87.59,60.29 v1(87.26,60.63)
  BOTTOM w0.254: U13.2 87.59,57.42 89.09,55.92 U13.6 89.09,54.03 89.29,53.84 89.97,53.84 90.17,53.64 90.18,53.63 C89.1
  BOTTOM w0.305: U24.10 v1(28.44,48.88)
  BOTTOM w0.381: U33.16 35.64,28.57 35.65,28.56 C188.1 v1(36.34,27.67) ; v1(44.3,60.69) C172.2 U27.1 ; v1(71.62,76.41) C276.1 U59.1 ; R124.2 v1(43.12,49.22) ; v1(26.03,66.41) 25.94,66.5 R277.1 ; v1(36.55,66.47) C234.1 36.46,67.18 36.46,67.19 35.57,67.19 35.56,67.18 U44.16 ; R133.1 v1(28.57,56.48) ; C89.1 v1(91.69,52.95) ; R204.1 v1(26.54,30.34) ; R160.1 v1(53.03,62.25) ; v1(43.26,64.5) R161.1
  vias: v1(103.81,35.14)
VSYS_MON: length 5.4
  TOP w0.381: U1.U2 v1(53.78,33.63)
  BOTTOM w0.381: TP57.1 53.61,31.02 R201.2 54.35,31.02 R203.1 54.4,32.09 54.4,32.92 C186.2 54.34,33.25 53.96,33.63 v1(53.78,33.63)
VSYS_TA_3V3: length 52.2
  TOP w0.203: U47.14 64.36,80.48 R321.2 64.45,80.98 U47.15
  TOP w0.381: R286.1 64.77,77.71 65.7,78.64 R287.1 65.7,79.91 v1(65.78,80) C244.1 ; C244.1 v1(66.54,80.78) ; C244.1 64.66,80.78 R321.2 ; v1(52.88,88.25) 53.14,88.52 R319.1 R318.1 R317.1 R316.1 ; v1(50.09,78.09) R72.1 R73.1 ; TP21.1 58.67,83.22 v1(58.67,84.82) ; U57.16 44.16,106.53 C351.2 v1(44.26,107.12) ; R320.2 v1(60.19,77.71)
  BOTTOM w0.203: C242.1 65.02,84.46 65.35,84.8 U48.3 ; v1(53.21,83.05) 53.22,83.05 53.44,82.82 U10.8
  BOTTOM w0.305: L5.2 56.66,85.1 54.44,82.88 U10.10
  BOTTOM w0.381: C239.1 v1(45.91,99.21) ; R288.2 R289.2 R290.2 R291.2 R292.2 ; U49.5 66.98,93.37 C246.2 v1(65.68,93.19) ; R292.2 v1(57.78,95.36) ; R292.2 R293.2 56.64,96.27 R468.2 ; v1(49.5,80.61) C272.2 49.47,79.97 U56.8 ; R58.2 v1(50.92,84.19) ; U50.5 63.67,91.53 C245.2 v1(63.77,90.68) ; U58.8 17.24,73.13 17.24,73.13 C275.1 v1(17.24,71.87) ; R307.2 46.47,74.94 C241.1 46.48,74.9 v1(46.48,74.03) ; C238.1 v1(45.94,97.96) ; C242.1 v1(64.28,83.79) ; R322.2 v1(63.37,82.16)
  vias: v1(59.69,85.33) v1(60.7,85.33)
VSYS_TA_3V3_EN: length 2.8
  BOTTOM w0.147: U10.3 53.44,79.43 53.27,79.26 52.2,79.26 52.06,79.11 R57.2
VSYS_TA_3V3_PG: length 1.8
  BOTTOM w0.203: R58.1 51.97,83.52 52.94,82.55 U10.7
VSYS_TA_3V3_SW: length 1.5
  BOTTOM w0.305: U10.9 53.94,83.33 53.72,83.55
WARMRESETN: length 110.2
  TOP w0.305: U1.C3 v1(54.58,45.63)
  TOP w0.381: R126.1 20.31,51.3 21.23,52.21 21.23,53.8 22.03,54.6 v1(22.98,54.6)
  L03_SIG1 w0.091: v1(22.98,54.6) 25,54.6 29.37,58.96 31.67,58.96 35.27,55.36 49.64,55.36 52.22,52.78 52.22,51.35 v1(52.98,50.58)
  L08_SIG2 w0.091: v1(22.98,54.6) 22.06,55.52 22.06,60.17 26.92,65.03 38.79,65.03 39.56,65.8 40.93,65.8 41.51,66.39 50.59,66.39 52.18,64.8 58.01,64.8 59.46,66.24 59.46,67.76 58.3,68.93 58.3,73.87 v1(55.96,76.21)
  BOTTOM w0.114: 54.18,47.51 54.18,46.03
  BOTTOM w0.147: 54.18,47.51 54.18,47.83 53.91,48.1 R185.2 53.21,50.05 52.98,50.28 v1(52.98,50.58) 52.52,50.58 52.34,50.77 TP58.1 ; 54.18,46.03 v1(54.58,45.63) ; R394.1 v1(55.96,76.21)
WARMRESETN_R: length 1.5
  TOP w0.381: U22.1 18.05,51.36 R126.2
XDS110_EMU0: length 2.7
  BOTTOM w0.147: R357.2 38.07,98.32 37.46,97.71 U52.42
XDS110_EMU1: length 2.5
  BOTTOM w0.147: R356.2 38.13,97.09 37.91,97.31 U52.43
XDS110_PROG_STAZ1: length 2.2
  TOP w0.147: v1(23.54,101.46) 23.54,100.73 R342.2
  BOTTOM w0.147: U52.4 v1(23.54,101.46)
XDS110_PROG_STAZ2: length 2.3
  TOP w0.147: R343.1 23.09,104.04 v1(23.14,104.09)
  BOTTOM w0.147: U52.3 v1(23.14,104.09)
XDS110_TCK: length 22.2
  L08_SIG2 w0.091: v1(43.81,88.95) 44.24,88.52 44.24,87.5 43.99,87.25 42.85,87.25 40.68,89.42 40.67,89.42 37.62,92.48 37.62,97.81 v1(34.92,100.51)
  BOTTOM w0.147: U52.35 v1(34.92,100.51) ; U31.3 v1(43.81,88.95)
XDS110_TCK_ISO: length 37.4
  TOP w0.147: v1(38.79,61.77) 38.76,61.74 U30.13
  L03_SIG1 w0.091: v1(38.79,61.77) 39.05,62.03 44.23,62.03 48,65.8 48,85.77 v1(51.18,88.95)
  BOTTOM w0.147: R198.1 v1(51.18,88.95)
XDS110_TDI: length 30.5
  L08_SIG2 w0.091: v1(31.66,78.39) 34.69,81.42 34.69,87.8 33.99,88.51 33.99,100.18 34.74,100.94 35.83,100.94 v1(37.46,99.31)
  BOTTOM w0.147: U52.38 v1(37.46,99.31) ; U32.7 v1(31.66,78.39)
XDS110_TDI_ISO: length 15.3
  TOP w0.147: U30.6 v1(33.27,60.44)
  BOTTOM w0.147: v1(33.27,60.44) 33.72,60.9 33.72,62.58 33.27,63.04 33.27,69.75 30.72,72.3 R199.1
XDS110_TDO: length 27.9
  L08_SIG2 w0.091: v1(34.92,99.71) 34.37,99.16 34.37,91.27 34.88,90.76 34.88,81 31.83,77.96 30.81,77.96 v1(30.39,78.39)
  BOTTOM w0.147: U32.6 v1(30.39,78.39) ; U52.37 v1(34.92,99.71)
XDS110_TDO_ISO: length 15
  TOP w0.147: U30.3 v1(33.27,62.39)
  BOTTOM w0.147: U32.3 30.39,73.97 29.93,73.51 29.93,72.37 32.89,69.41 32.89,62.77 v1(33.27,62.39)
XDS110_TMS: length 18
  L08_SIG2 w0.091: v1(37.46,100.11) 38.1,99.48 38.1,92.58 39.76,90.92 40.57,90.92 v1(43.81,87.68)
  BOTTOM w0.147: U31.2 v1(43.81,87.68) ; U52.36 v1(37.46,100.11)
XDS110_TMS_ISO: length 41.5
  TOP w0.147: U30.10 v1(38.85,59.79)
  L03_SIG1 w0.091: v1(38.85,59.79) 38.85,59.42 40.41,57.85 43.97,57.85 45.97,59.85 45.97,63.14 48.27,65.45 48.27,85.57 50.38,87.68 v1(51.18,87.68)
  BOTTOM w0.147: R197.1 50.99,87.68 50.99,87.68 v1(51.18,87.68)
XDS110_TRST#: length 3.2
  BOTTOM w0.147: U52.40 37.67,98.51 37.97,98.8 37.97,99.43 38.1,99.56 R337.1
XDS110_UART0_RXD: length 13.2
  L08_SIG2 w0.091: v1(37.47,101.32) 39.34,99.45 39.34,97.52 43.14,93.71 v1(43.81,93.71)
  BOTTOM w0.147: U52.33 37.45,101.31 37.46,101.32 v1(37.47,101.32) ; U54.6 v1(43.81,93.71)
XDS110_UART0_TXD: length 11.5
  L08_SIG2 w0.091: v1(43.81,94.98) 42.29,94.98 39.67,97.61 v1(39.67,101.67)
  BOTTOM w0.147: U54.7 v1(43.81,94.98) ; R336.1 v1(39.67,101.67)
XDS110_VBUS_DET: length 3.3
  BOTTOM w0.147: R341.1 R340.2 U52.1
XDS_GND: length 68
  TOP w0.381: v1(25.06,91.6) C260.2 C259.2 ; U51.6 v1(18.35,103.83) ; v1(39.65,80.51) 39.75,80.41 39.75,79.46 R315.2 39.78,79.3 C352.2 ; R333.2 v1(17.17,105.68) ; LD10.1 v1(23.11,105.39) ; J13.5 v1(14.19,93.68) ; C273.1 v1(30.49,106.68) 30.48,106.67 ; v1(34.41,88.76) 34.52,88.65 C262.2 ; v1(27.17,99.37) C268.2 C267.2 26.84,97.75 U55.1 ; C249.2 v1(20.95,101.84) ; LD9.1 v1(23.49,97.27)
  BOTTOM w0.203: U52.17 28.74,104.05 28.97,104.27 C250.2 ; C251.2 25.76,104.31 25.94,104.12 U52.10 ; U52.55 v1(34.93,92.51) ; U52.64 34.56,88.91 v1(34.41,88.76) 34.34,88.69 U52.66 34.34,86.25 34.27,86.17 C255.2 ; C252.2 28.21,85.98 28.74,86.52 U52.80 ; C254.2 19.25,95.73 19.27,95.71 U52.114 ; C253.2 37.7,94.87 37.26,95.31 U52.48 ; U52.58 v1(34.93,91.31)
  BOTTOM w0.305: U53.3 14.19,94.18 v1(14.19,93.68)
  BOTTOM w0.381: R350.1 R351.1 40.87,85.41 C182.1 v1(40.89,84.7) ; C258.2 v1(34.92,104.89) ; R358.2 R349.1 v1(40.51,90.19) ; C257.2 v1(38.98,92.84) ; v1(29.12,81.65) U32.5 ; C252.2 v1(28.21,84.57) ; R355.2 v1(36.17,81.67) ; C253.2 v1(38.98,94.87) ; C261.2 v1(18.33,97.6) ; R341.2 v1(21.36,107.01) ; R337.2 v1(40.25,99.56) ; C270.1 v1(23.77,86.18) ; R352.1 v1(36.12,83.62) ; C251.2 v1(25.76,105.88) ; C271.1 39.85,80.23 39.84,80.24 39.84,80.32 v1(39.65,80.51) ; U58.3 v1(19.78,80.92) ; C266.2 v1(40.13,95.26) ; C264.2 v1(21.2,83.02) ; C180.1 v1(31.11,81.65) ; C255.2 v1(34.27,84.59) ; U31.4 v1(43.81,90.22) ; Y2.2 v1(24.42,80.8) ; C274.2 v1(17.21,82.41) ; U54.5 v1(43.81,92.44) ; U56.4 v1(40.89,83.78) ; C254.2 v1(17.65,95.73) ; C250.2 v1(28.97,105.91) ; U58.4 v1(21.05,80.92) ; C269.1 v1(26.75,86.18) ; Y2.4 v1(28.19,83.59)
  vias: v1(13.58,87.11) v1(13.58,85.97) v1(15.11,101.78) v1(17.01,101.97) v1(17.01,100.95) v1(18.03,101.97) v1(18.03,100.95) v1(19.05,101.97) v1(19.05,100.95) v1(22.22,80.12) v1(22.22,78.85) v1(27.05,80.12) v1(27.05,78.98)
XDS_RBIAS: length 2.6
  BOTTOM w0.147: R358.1 37.75,91.38 37.28,90.91 U52.59
XDS_USB_D_N: length 19.3
  TOP w0.107: J13.2 14.05,95.63 14.17,95.51 14.75,95.51 v1(14.98,95.75)
  L08_SIG2 w0.094: v1(23.74,89.14) 23.58,89.31 23.58,92.13 19.1,96.61 16.94,96.61 15.94,95.6 15.13,95.6 v1(14.98,95.75)
  BOTTOM w0.107: U53.1 14.16,95.61 14.29,95.48 14.71,95.48 v1(14.98,95.75) ; U52.93 23.54,88.4 23.51,88.43 23.51,88.91 v1(23.74,89.14)
XDS_USB_D_P: length 19.2
  TOP w0.107: v1(14.98,94.98) 14.67,95.3 14.26,95.3 13.95,94.98 J13.3
  L08_SIG2 w0.094: v1(22.98,89.14) 23.33,89.49 23.33,92.03 19,96.36 17.05,96.36 16.04,95.35 15.35,95.35 v1(14.98,94.98)
  BOTTOM w0.107: v1(22.98,89.14) 23.29,88.83 23.29,88.55 23.14,88.4 U52.94 ; v1(14.98,94.98) 14.71,95.26 14.31,95.26 14.16,95.11 U53.2
XDS_USB_ID: length 2.7
  BOTTOM w0.147: R338.1 22.47,85.36 22.74,85.63 U52.95
XDS_VREF: length 6.2
  TOP w0.147: U55.3 C267.1 C268.1 R354.2 v1(25.54,101.48)
  BOTTOM w0.147: U52.9 v1(25.54,101.48)
XTAL_IN: length 12.1
  TOP w0.147: U1.T1 52.62,34.83 52.32,34.53 52.32,32.25 51.7,31.62 R178.2 50.85,30.95 48.81,28.91 47.05,28.91 46.59,29.37 R176.2
XTAL_OUT: length 4.5
  TOP w0.147: R179.2 51.54,32.95 51.81,33.22 51.81,34.79 52.66,35.63 U1.R1
N23200398: length 4.4
  BOTTOM w0.147: R339.1 C264.1 21.24,84.81 22.34,85.91 U52.96
N23200423: length 3.8
  BOTTOM w0.147: U52.60 37.81,90.51 38.13,90.19 R349.2 R345.1
N23200491: length 1.3
  TOP w0.147: LD10.2 22.09,103.72 22.11,103.71 R343.2
N23200507: length 6.3
  BOTTOM w0.147: U52.63 37.16,89.31 37.33,89.14 37.33,85.82 37.31,85.8 R348.1 R352.2
N23200509: length 5.3
  BOTTOM w0.147: R350.2 R346.1 38.69,87.84 38.1,88.43 38.1,89.65 37.63,90.11 U52.61
N23200516: length 7.2
  BOTTOM w0.147: R347.1 R351.2 38.69,85.45 37.71,86.43 37.71,89.4 37.4,89.71 U52.62
N23200616: length 0.8
  TOP w0.147: LD9.2 R342.1
N31943874: length 9.6
  TOP w0.147: v1(43.94,74.92) U46.8 41.33,74.92 40.82,74.41 40.13,74.41 39.53,75.01 R308.1 39,75.04 38.55,75.5 R306.1 R309.1
  BOTTOM w0.147: v1(43.94,74.92) 43.96,74.94 R307.1
N32133653: length 1.9
  BOTTOM w0.147: U49.4 68.88,93.96 69.18,93.65 R329.2
N32133735: length 1.9
  TOP w0.147: SW6.5 R319.2
N32133737: length 1.9
  TOP w0.147: SW6.6 55.29,87.25 55.28,87.24 R318.2
N32133754: length 1.9
  TOP w0.147: SW6.7 R317.2
N32133756: length 1.9
  TOP w0.147: SW6.8 R316.2
N32302430: length 2.9
  TOP w0.147: C336.1 R425.2 52.7,105.85 52.69,105.84 SW10.4
N32359377: length 2.9
  TOP w0.147: C338.1 R429.2 66.61,106.37 SW12.4
N32360252: length 2.9
  TOP w0.147: SW11.4 59.69,104.83 R426.2 C337.1
N32781982: length 5.5
  BOTTOM w0.147: U26.9 40.52,67.66 39.86,68.33 R166.1 U26.12
N32800162: length 1.6
  TOP w0.147: U47.16 63.84,81.48 64.12,81.76 R321.1
N32800169: length 1.6
  TOP w0.147: U47.11 R320.1
N32801024: length 1.3
  TOP w0.147: LD11.2 R381.1
N32801040: length 1.3
  TOP w0.147: LD12.2 R382.1
N32801094: length 1.3
  TOP w0.147: LD13.2 R383.1
N32801104: length 1.3
  TOP w0.147: LD14.2 R384.1
N32801160: length 1.4
  TOP w0.147: LD15.2 R385.1
N32801170: length 1.4
  TOP w0.147: LD16.2 R386.1
N32801226: length 1.4
  TOP w0.147: LD17.2 R387.1
N32801236: length 1.4
  TOP w0.147: LD18.2 R388.1
N32801519: length 1.6
  BOTTOM w0.147: R389.2 U59.9
N32801526: length 1.6
  BOTTOM w0.147: U59.10 R390.2
N32801533: length 2.1
  BOTTOM w0.147: R391.2 71.26,69.69 70.99,69.96 U59.7
N32817219: length 4.4
  BOTTOM w0.147: R392.1 R393.2 53.42,73.91 53.72,73.61 54.63,73.61 54.96,73.29 U60.26
N32817226: length 1.9
  BOTTOM w0.147: R394.2 U60.28
N32843337: length 1.7
  TOP w0.147: SW1.2 R184.2
N32845049: length 20.3
  TOP w0.381: U41.6 26.56,35.19 26.57,35.2 C232.1 v1(27.94,35.2) C231.1 ; FL6.2 v1(20.37,47.55)
  L08_SIG2 w0.381: v1(27.94,35.2) 20.37,42.76 v1(20.37,47.55)
N32845083: length 3.5
  TOP w0.147: U41.1 18.27,36.49 17.77,36.99 R271.2 R273.2
N32845192: length 2.6
  TOP w0.147: U41.3 18.12,35.19 17.21,34.28 R272.1
N32845194: length 2.3
  TOP w0.147: U41.8 26.25,36.49 27.12,37.36 R274.1
N32845196: length 16.9
  TOP w0.147: R275.1 39.73,31.47 38.73,32.47 36.14,32.47 35.83,32.78 35.83,33.82 35.12,34.54 U41.5
N32845712: length 2.2
  TOP w0.147: U1.V9 R396.1
N32845714: length 4.2
  TOP w0.147: U1.T8 v1(58.58,34.43)
  BOTTOM w0.114: 58.98,33.2 58.98,34.03
  BOTTOM w0.147: 58.98,33.2 59.3,32.88 R397.1 ; 58.98,34.03 v1(58.58,34.43)
N32851242: length 2.2
  TOP w0.147: R331.1 J12.2
N32911629: length 4.1
  BOTTOM w0.147: U76.1 53.56,90.8 53.86,90.49 R541.1 C377.2
N32911790: length 5.6
  BOTTOM w0.147: R542.1 C378.2 54.99,91.55 54.27,92.27 52.9,92.27 52.56,91.92 U76.3
N32914108: length 2.5
  BOTTOM w0.147: U52.34 37.27,100.91 37.38,100.8 R336.2
N32995593: length 3.3
  TOP w0.147: R77.1 101.85,84.94 101.63,85.16 v1(101.04,85.16) R79.1
  BOTTOM w0.147: U14.4 100.63,85.58 v1(101.04,85.16)
N32995608: length 2.4
  BOTTOM w0.254: U14.2 99.89,86.76 99.89,86.75 99.12,86.75 99.12,86.76 99.01,86.76 98.31,86.05
N32995634: length 1.6
  TOP w0.147: C95.1 v1(100.13,88.77)
  BOTTOM w0.147: U14.9 v1(100.13,88.77)
N33038314: length 1.1
  TOP w0.147: R48.2 104.44,55.98 105.18,55.98 105.2,55.99 105.41,55.99 LD3.2
N33056127: length 1
  TOP w0.147: LD6.2 R137.2
N33056129: length 1.5
  TOP w0.147: Q3.3 LD6.1
N33056157: length 2.6
  TOP w0.147: Q3.1 R146.1 R148.1
N33200463: length 3.2
  TOP w0.147: R139.2 61.41,47.34 61.38,47.31 U1.A11
N33200513: length 3.2
  TOP w0.147: U1.A10 60.58,48.44 60.2,48.82 R140.2
N33221101: length 3.3
  TOP w0.147: U1.U4 v1(55.38,33.63)
  BOTTOM w0.114: 55.78,32.57 55.78,33.23
  BOTTOM w0.147: R400.1 55.72,32.51 55.78,32.57 ; 55.78,33.23 v1(55.38,33.63)
N33221125: length 3.4
  TOP w0.147: U1.U5 v1(56.18,33.63)
  BOTTOM w0.147: R398.1 56.92,32.89 v1(56.18,33.63)
N33221128: length 2.4
  TOP w0.147: U1.V3 54.86,33.11 54.86,31.44 R399.1
N33235493: length 1.4
  BOTTOM w0.147: R328.2 63.43,92.82 63.43,92.83 U50.4
N33277398: length 2.6
  TOP w0.147: R149.1 R147.1 Q4.1
N33277404: length 1
  TOP w0.147: LD7.2 R138.2
N33277419: length 1.5
  TOP w0.147: Q4.3 LD7.1
N33334993: length 1.9
  BOTTOM w0.147: U27.2 44.92,62.73 44.63,63.02 R163.1
N33461336: length 5.6
  TOP w0.147: J15.43 34.24,4.41 33.65,5 33.65,5 33.38,5.27 R416.1
N33514520: length 2.7
  BOTTOM w0.147: U50.2 R327.2 C247.1
N33770351: length 1.5
  TOP w0.147: R275.2 40.56,30.01 40.57,30.02 U43.2
N33879615: length 3.4
  TOP w0.147: U1.A9 59.78,48.28 58.99,49.07 R143.1
N33879618: length 4.2
  TOP w0.147: U1.B9 v1(59.38,46.43)
  BOTTOM w0.147: v1(59.38,46.43) 59.38,46.89 59.37,46.89 59.37,47.57 58.99,47.95 R145.1
N33879812: length 1.9
  TOP w0.147: R283.2 24.63,68.09 24.63,68.1 U45.4
N33879815: length 3.1
  TOP w0.147: U45.1 R282.2 R284.2
N33880944: length 5.9
  BOTTOM w0.147: U44.12 R281.1 36.55,71 35.82,71.73 U44.9
N33881371: length 17.1
  TOP w0.147: J10.2 12.91,68.1 14.07,66.93 C237.1 16.7,66.93 16.8,66.83 U45.6 20.35,66.83 20.7,67.17 20.7,69.84 21.61,70.75 SW5.1
N33882160: length 1.6
  TOP w0.147: R278.1 D6.1
N33883080: length 1.8
  TOP w0.147: R278.2 SW5.2
N33884757: length 1.9
  BOTTOM w0.147: U54.2 R344.2
N33885275: length 1.6
  BOTTOM w0.147: U32.2 31.66,72.93 R199.2
N33885316: length 1.7
  BOTTOM w0.147: U31.7 R197.2
N33885344: length 1.7
  BOTTOM w0.147: U31.6 R198.2
N33933588: length 1.8
  BOTTOM w0.147: U74.9 64.26,23.77 64.06,23.57 R412.1
N33933633: length 1.8
  BOTTOM w0.147: R413.1 65.45,23.43 65.26,23.61 U74.7
N33986982: length 4.5
  TOP w0.147: SW4.3 D7.1 C235.1
N34075368: length 1.7
  BOTTOM w0.147: U27.3 R163.2
N34422674: length 3.6
  TOP w0.147: U1.A13 63.32,47.17 63.32,47.96 62.62,48.67 R135.2
N34422702: length 4.3
  TOP w0.147: U1.B13 v1(63.38,46.43)
  BOTTOM w0.147: v1(63.38,46.43) 63.38,48.76 63.91,49.29 R136.2
N34549994: length 5.2
  TOP w0.147: U1.C9 v1(59.38,45.63)
  BOTTOM w0.147: R144.2 60.25,48.43 60.07,48.25 60.07,46.32 v1(59.38,45.63)
N34603287: length 3.6
  TOP w0.147: U1.N1 v1(52.83,37.23)
  BOTTOM w0.147: v1(52.83,37.23) 52.1,36.51 51.88,36.51 51.56,36.18 50.9,36.18 50.83,36.26 R90.2
N34603290: length 6.3
  TOP w0.147: U1.N4 v1(55.38,36.83)
  BOTTOM w0.114: 54.4,37.23 54.75,37.23
  BOTTOM w0.147: 54.4,37.23 54.14,37.23 54.05,37.14 53.65,37.14 53.04,37.75 51.17,37.75 50.83,37.4 R91.2 ; 54.75,37.23 54.98,37.23 v1(55.38,36.83)
N34603328: length 4.9
  TOP w0.147: U1.K1 51.57,41.44 51.57,42.03 50.76,42.84 R97.2
N34603356: length 4.8
  TOP w0.147: U1.N2 53.77,36.82 53.22,36.82 53.22,36.81 52.37,36.81 51.56,37.62 50.82,37.62 50.2,38.23 R87.2
N34603584: length 7.4
  TOP w0.147: U1.M4 v1(55.38,37.63)
  BOTTOM w0.114: 54.98,38.16 54.98,38.6 54.75,38.83 54.75,38.83 54.33,38.83
  BOTTOM w0.147: R92.2 50.54,40.56 51.1,40.56 52.91,38.75 54.04,38.75 54.12,38.83 54.33,38.83 ; v1(55.38,37.63) 54.98,38.03 54.98,38.16
N34603591: length 5.6
  TOP w0.147: U1.P3 v1(54.58,36.03)
  BOTTOM w0.147: v1(54.58,36.03) 54.12,36.49 53.48,36.49 52.11,35.12 R93.2
N34660939: length 4.1
  BOTTOM w0.147: TP72.1 30.22,85.46 30.74,85.98 U52.75
N34662299: length 1.7
  BOTTOM w0.147: U56.6 R361.1
N34662301: length 1.7
  BOTTOM w0.147: U56.7 R362.1
N34663370: length 2.9
  BOTTOM w0.147: R296.2 56.88,99.9 58.24,101.25 J11.27
N34663404: length 2.7
  BOTTOM w0.147: J11.30 59.74,100.8 58.84,99.9 R298.2
N34663407: length 2.4
  BOTTOM w0.147: R299.2 60.07,100.57 60.24,100.74 J11.31
N34663410: length 2.4
  BOTTOM w0.147: R300.2 60.74,100.23 J11.32
N34663413: length 2.7
  BOTTOM w0.147: J11.28 58.74,100.79 57.85,99.9 R297.2
N34663434: length 2.7
  BOTTOM w0.147: J11.33 61.24,100.76 62.1,99.9 R301.2
N34665841: length 2.5
  BOTTOM w0.147: J11.36 62.74,100.77 63.11,100.39 R302.2
N34665844: length 2.7
  BOTTOM w0.147: R303.2 64.13,99.9 63.24,100.79 J11.37
