# Allegro board PROC159B.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
V3V3_XDS_FB: length 4.1
  TOP w0.381: R332.2 R333.1 ; R332.2 U51.5 ; R332.2 C248.2
VBAT_LIN: length 2.4
  TOP w0.381: D7.2 J9.1
VBAT_XDS: length 3.8
  TOP w0.381: v1(33.54,88.74) 33.54,87.49 C262.1 R334.2
  BOTTOM w0.203: U52.68 v1(33.54,88.74)
VBUS_DET: length 1.2
  BOTTOM w0.203: R5.1 103.18,13.53 U17.4
VBUS_MAIN: length 7.2
  TOP w0.381: v1(97.15,17.89) 96.9,17.64 U4.2
  BOTTOM w0.381: R10.1 101.1,22.78 100.82,23.06 R11.1 100.29,23.42 99.91,23.8 v1(98.77,23.8) v1(97.75,23.8)
  vias: v1(97.15,18.78) v1(98.04,18.78) v1(98.04,17.89)
VBUS_USBC: length 18.1
  TOP w0.254: R1.1 101.96,13.55 102.08,13.68 U2.5
  TOP w0.305: 106.05,21.03 105.53,21.55 105.53,21.58 ; 106.05,21.03 J1.A9 107.53,21.03 107.56,21.07 107.85,20.78 J1.B4 ; 106.05,21.03 105.66,20.64 105.66,20.43 ; 105.79,18.28 106.03,18.03 J1.A4 107.55,18.03 107.56,18.02 107.82,18.28 J1.B9
  TOP w0.381: v1(100.19,14.64) C2.1 R1.1
  BOTTOM w0.203: U17.12 99.66,13.93 C1.1
  BOTTOM w0.254: C1.1 99.41,14.39 99.67,14.64 v1(100.19,14.64)
  BOTTOM w0.381: R6.1 103.28,10.62 103.02,10.37 R4.1 R3.1 v1(100.2,10.37) ; R5.2 v1(104.9,13.91)
  vias: v1(102.36,21.83) v1(102.36,21.07) v1(102.36,20.31) v1(102.36,19.67) v1(103.25,20.31) v1(103.25,19.67) v1(104.01,20.31) v1(104.01,19.67) v1(104.01,18.53) v1(105.02,18.53)
VBUS_XDS110: length 7.1
  TOP w0.381: U51.8 v1(17.05,103.83)
  BOTTOM w0.305: v1(15.11,99.3) 13.16,97.35 U53.6
  BOTTOM w0.381: R339.2 v1(19.93,83.05) ; R340.1 v1(21.36,103.97)
VCC2V5_PG: length 21.7
  TOP w0.254: v1(96.21,80.94) 98.06,82.79 98.06,85.24 98.62,85.8 99.49,85.8 v1(100.13,85.16) ; v1(100.13,85.16) 100.47,84.82 R80.2 ; v1(100.13,85.16) 100.13,86.24 100.74,86.85 101.19,86.85 104.61,90.27 R81.1
  BOTTOM w0.254: U14.5 v1(100.13,85.16)
  BOTTOM w0.381: U16.3 93.37,80.71 93.76,80.32 95.59,80.32 v1(96.21,80.94)
VCC3V3_XDS: length 76.7
  TOP w0.381: R369.1 R368.1 R367.1 R366.1 R365.1 ; R369.1 v1(30.09,100.18) ; R369.1 R370.1 ; U57.1 33.33,106.68 C273.2 v1(31.64,107.28) ; C248.1 R332.1 19.98,99.86 ; R334.1 v1(35.56,86.22) ; C352.1 37.86,78.08 v1(37.89,78.04) R306.2 ; R354.1 v1(27.17,100.67)
  BOTTOM w0.203: v1(22.22,98.92) 22.21,98.91 U52.122 ; C250.1 27.99,104.45 28.34,104.1 U52.16 ; U52.47 37.3,95.71 37.44,95.85 C253.1 ; U52.101 v1(22.19,90.51) ; C255.1 33.14,85.6 U52.69 ; U52.113 19.75,95.31 19.19,94.75 C254.1 ; U52.52 37.4,93.71 37.51,93.82 37.22,94.11 U52.51 ; U52.7 24.74,104.27 24.78,104.31 25.14,103.94 U52.8 ; U52.28 33.14,103.84 32.68,104.31 32.34,103.97 U52.26 ; U52.39 v1(34.93,98.91) ; U52.90 v1(24.74,88.72) ; C252.1 29.19,86.09 29.14,86.13 U52.79
  BOTTOM w0.381: R357.1 R356.1 39.67,96.57 v1(40,96.24) C266.1 40.91,96.25 U54.8 ; v1(32.33,105.91) 32.68,105.56 C258.1 32.68,104.31 ; v1(39.11,82.51) R360.1 39.8,83.12 39.67,83.25 R347.2 ; U32.8 C180.2 ; C180.2 34.14,81.65 R353.1 ; C180.2 v1(32.93,82.41) ; v1(40.51,89) R345.2 R346.2 ; C252.1 v1(29.19,84.57) ; U58.1 17.24,81.14 C274.1 v1(16.51,81.17) ; v1(40.41,80.48) C271.2 41.11,79.87 41.21,79.97 U56.1 ; U31.1 C182.2 v1(40.89,87.24) ; C254.1 v1(17.65,94.75) ; 37.51,93.82 C257.1 v1(38.98,93.82) ; R377.1 v1(18.51,82.41) ; 24.78,104.31 C251.1 v1(24.78,105.91) ; R359.1 v1(39.11,81.24) ; R348.2 v1(37.31,83.57) ; C255.1 v1(33.29,84.57) ; C250.1 v1(27.99,105.91) ; C253.1 v1(38.98,95.85)
  vias: v1(22.22,100.06)
VCC_1V1: length 29.4
  TOP w0.254: U15.1 107.45,88.02 C97.1 107.49,87.56
  TOP w0.381: 107.49,87.56 TP30.1 107.49,84.03 103.51,80.05 101.7,80.05 99.81,78.16 v1(99.15,78.16)
  BOTTOM w0.381: FL4.1 87.76,79.55 88.05,79.84 93.09,79.84 93.81,79.12 98.19,79.12 v1(99.15,78.16)
VCC_1V2: length 28.4
  TOP w0.381: U1.K6 v1(56.98,39.23) ; v1(70.25,43.19) 70.38,43.06 C120.1 C121.1 ; U1.G6 v1(56.98,42.43) ; U1.G5 v1(56.18,42.43) ; U1.J15 v1(64.98,40.83) ; U1.N5 v1(56.18,36.83) ; U1.E11 v1(61.78,44.03) ; U1.D10 v1(60.98,44.83) ; U1.N14 v1(64.18,36.83) ; U1.E9 v1(59.38,44.03) ; U1.K13 v1(63.38,39.23) ; U1.R9 v1(59.38,35.23) ; U1.N6 v1(56.98,36.83) ; U1.F9 v1(59.38,43.23) ; U1.J16 v1(65.78,40.83) ; U1.F11 v1(61.78,43.23) ; U1.H3 v1(54.58,41.63) ; U1.N13 v1(63.38,36.83) ; U1.G14 v1(64.18,42.43) ; U1.K14 v1(64.18,39.23) ; U1.G13 v1(63.38,42.43) ; U1.K5 v1(56.18,39.23)
  BOTTOM w0.305: C116.1 63.25,36.96 v1(63.38,36.83) ; C112.1 64.12,39.29 v1(64.18,39.23) ; C113.1 64.05,36.96 v1(64.18,36.83) ; C111.1 59.49,43.12 v1(59.38,43.23) 59.25,43.1 C126.1 ; v1(60.98,44.83) 60.87,44.72 C118.1 ; C115.1 63.25,42.56 v1(63.38,42.43) ; C128.1 56.29,42.54 v1(56.18,42.43) ; v1(56.18,39.23) 56.22,39.27 C129.1 ; C127.1 61.89,43.92 v1(61.78,44.03) ; v1(63.38,39.23) 63.27,39.34 C114.1 C123.1 ; C125.1 57.09,42.54 v1(56.98,42.43) ; C122.1 56.99,39.23 v1(56.98,39.23) 56.87,39.12 C131.1 ; v1(64.98,40.83) 64.87,40.94 C124.1 ; v1(56.18,36.83) 56.05,36.96 C117.1 ; C130.1 56.85,36.96 v1(56.98,36.83) ; C133.1 61.65,43.1 v1(61.78,43.23) ; C110.1 59.25,43.9 v1(59.38,44.03) ; v1(64.18,42.43) 64.05,42.56 C132.1
  BOTTOM w0.381: v1(84.2,49.01) 84.2,49.69 R75.2 ; v1(70.25,43.19) C119.1 C103.1 v1(73.87,43.19) C102.1
  vias: v1(81.53,49.01) v1(81.53,48.12) v1(81.53,47.23) v1(82.42,49.01) v1(82.42,48.12) v1(82.42,47.23) v1(83.31,49.01) v1(83.31,48.12) v1(83.31,47.23) v1(84.2,48.12) v1(84.2,47.23)
VCC_1V2_N: length 3.8
  BOTTOM w0.108: R75.1 85.41,50.02 85.77,50.02 86.12,49.67 87.4,49.67 87.65,49.92 87.65,50.33 R70.2
VCC_1V2_P: length 3.4
  BOTTOM w0.108: R75.4 85.43,50.28 85.88,50.28 86.23,49.93 87.3,49.93 87.39,50.02 87.39,50.33 R68.2
VCC_1V8_LDO4: length 11
  TOP w0.254: v1(106.48,48.63) C72.1 106.48,47.2 106.69,46.99 U7.30
  TOP w0.381: R3833.1 103.92,57.68 104.45,57.14 v1(105.14,57.14) ; v1(39.46,22.69) 39.45,22.7 SW7.1
  BOTTOM w0.381: R36.2 v1(112.57,34.4) ; v1(105.14,57.14) 105.14,56.51 TP20.1
VCC_2V5_EN: length 1.8
  TOP w0.147: R78.1 v1(99.21,85.16)
  BOTTOM w0.254: v1(99.21,85.16) 99.63,85.58 U14.6
VCC_5V0: length 6.3
  TOP w0.305: U29.3 23.41,22.91 C174.2
  TOP w0.381: v1(66.29,4.43) 66.66,4.43 67.04,4.05 J15.117 ; C174.2 v1(24.51,22.58)
  BOTTOM w0.381: v1(24.51,22.58) 24.49,22.59 FB1.2
VCC_6V0_BBOUT: length 12.7
  TOP w0.254: 101.19,46.33 U7.41 ; U9.6 93.13,57.75 94.96,55.92 C80.1 ; 100.69,46.22 U7.42
  TOP w0.305: 101.29,47.45 101.29,47.49
  TOP w0.381: U66.6 90.23,46.87 90.51,47.15 C345.1 ; 101.19,46.33 101.46,46.6 101.46,47.38 101.35,47.49 C31.1 101.16,47.37 100.69,46.9 100.69,46.22
  vias: v1(100.83,53.83) v1(100.83,51.8) v1(101.21,49.64) v1(101.21,48.25) v1(101.6,53.83) v1(101.6,51.8)
VCC_PLDO1: length 8.5
  TOP w0.305: C76.1 107.78,35.33 107.26,35.85 107.26,36.38 107.19,36.45 U7.20
  TOP w0.381: v1(107.78,33.56) C76.1
  BOTTOM w0.381: C74.1 110.01,35.54 110.87,35.54 111.21,35.88 111.21,37.26 J3.1
VCC_PLDO2: length 6.3
  TOP w0.254: v1(107.59,48.63) C79.1 107.59,47.24 107.19,46.84 U7.29
  BOTTOM w0.381: v1(107.59,48.63) 107.59,50.12 107.82,50.34 v1(107.82,50.91)
VDD1V1A: length 16.5
  TOP w0.381: C197.1 v1(87.28,75.08) ; C191.1 C192.1 85.3,68.84 v1(84.32,68.84) ; v1(93.47,68.84) C195.1
  BOTTOM w0.305: U35.6 v1(93.47,68.84) ; U35.31 v1(84.32,68.84) ; U35.39 87.42,72.96 86.87,73.51 C196.1
  BOTTOM w0.381: C196.1 86.87,74.67 v1(87.28,75.08) 86.51,75.84 C190.1 ; v1(93.47,68.84) C195.1 ; C190.1 FL4.2 85.93,77.9 85.55,77.52 v1(85.55,76.99) ; C190.1 v1(85.55,75.97) ; C193.1 84.31,68.86 v1(84.32,68.84)
VDD2V5A: length 3
  BOTTOM w0.305: U35.9 v1(93.47,67.34) ; U35.3 v1(93.47,70.34)
  BOTTOM w0.381: C211.1 v1(93.47,70.34) ; C209.1 v1(93.47,67.34)
VDD_2V5: length 10.9
  TOP w0.203: 71.69,88.24 J8.4
  TOP w0.254: 103.71,86.44 104.49,87.22 C96.1 104.99,88.15 105.12,88.02 U15.4
  TOP w0.381: C220.1 v1(69.59,89.14) ; C221.1 71.57,88.36 71.69,88.24
  BOTTOM w0.381: 103.84,86.39 102.62,86.39 102.3,86.07 U14.3 ; v1(102.65,84.09) 102.65,82.53 101.95,81.83
  vias: v1(70.48,89.14) v1(95.12,75.68) v1(95.12,74.79) v1(103.41,83.13) v1(103.41,82.16) v1(103.66,84.09)
VDD_5V0_LDO3: length 147.7
  TOP w0.305: C69.1 104.69,35.61 104.8,35.71 104.8,36.15 104.7,36.25 104.7,36.31 104.69,36.31 U7.15
  TOP w0.381: TP19.1 104.68,33.35 v1(104.68,33.74) 104.69,33.76 C69.1 ; v1(60.85,75.93) R388.2 60.85,74.92 61.21,74.56 61.21,74.02 60.85,73.66 R387.2 R386.2 R385.2 ; SW4.1 v1(11.3,60.05) ; v1(73.34,78.07) 73.64,77.77 R3834.1 R381.2 R382.2 R383.2 R384.2
  L03_SIG1 w0.381: v1(11.3,60.05) 13.9,60.05 17.45,56.5 17.45,33.57 18.39,32.63 22.27,32.63 23.23,31.68 23.23,27.39 20.7,24.86 v1(20.7,22.59)
  L05_PWR1 w0.381: v1(73.34,78.07) 73.91,78.07 74.04,78.2 76.01,78.2 77.19,79.39 80.28,79.39 82.79,76.88 83.81,76.88 86.24,74.45 86.24,73.43 87.29,72.38 92.24,72.38 94.99,69.63 94.99,61.7 95.78,60.92 95.78,59.96 101.03,54.71 106.28,54.71 107.81,53.18 108.5,53.18 110.42,51.26 110.42,44.89 109.41,43.89 109.41,39.19 107.77,37.54 106.28,37.54 104.83,36.1 104.83,35.69 104.83,35.69 104.83,34.14 104.55,33.87 v1(104.68,33.74)
  BOTTOM w0.381: FB1.1 v1(20.7,22.59)
VDD_IO_3V3: length 11
  TOP w0.381: FL1.1 69.46,34.84 v1(69.38,34.92) ; U1.D12 v1(62.58,44.83) ; v1(68.83,39.69) 68.96,39.56 C149.1 ; U1.H4 v1(55.38,41.63) ; v1(68.83,41.5) 68.96,41.37 C148.1 ; U1.L15 v1(64.98,38.43) ; U1.D8 v1(58.58,44.83) ; U1.P4 v1(55.38,36.03) ; U1.H15 v1(64.98,41.63) ; U1.R15 v1(64.98,35.23)
  L06_PWR2 w0.203: v1(64.98,35.23) 65.32,34.89 65.42,34.89
  L06_PWR2 w0.381: 65.03,35.23 65.43,35.63 ; 65.03,35.23 v1(64.98,35.23) ; 65.03,35.23 65.08,35.23 65.25,35.06 65.25,35.01 65.43,34.83
  BOTTOM w0.305: v1(55.38,41.63) 55.51,41.76 C154.1 ; v1(55.38,36.03) 55.51,36.16 C150.1 ; v1(64.98,38.43) 64.87,38.54 C153.1 ; v1(58.58,44.83) 58.56,44.83 C152.1 ; v1(64.98,41.63) 64.87,41.74 C155.1 ; v1(62.58,44.83) 62.58,44.81 C156.1
  BOTTOM w0.381: C139.1 64.75,35.46 v1(64.98,35.23)
  vias: v1(69.59,38.47) v1(104.39,59.04) v1(104.39,58.15) v1(105.41,59.04) v1(105.41,58.15)
VDD_IO_3V3_N: length 1.9
  BOTTOM w0.108: R71.2 100.67,57.94 101.61,57.94 R74.1
VDD_IO_3V3_P: length 1.9
  BOTTOM w0.108: R74.4 101.65,57.65 100.67,57.65 100.25,57.22 R69.2
VDD_MMC1: length 7.1
  TOP w0.381: U23.5 17.51,56.25 17.9,56.64 C169.1 18.79,56.77 18.36,57.2 U23.6 ; v1(23.45,51.13) 23.49,51.17 C170.1
  BOTTOM w0.381: J4.4 v1(23.45,51.13)
  vias: v1(22.73,56.38) v1(23.62,56.38)
VDDA1V8_OSC_PLL_F: length 2
  TOP w0.305: U1.R4 v1(55.38,35.23)
  BOTTOM w0.305: v1(55.38,35.23) 55.51,35.36 C146.1
  BOTTOM w0.381: FL2.2 v1(49.55,28.08)
VDDA3V3_F: length 4.9
  TOP w0.381: U1.P7 v1(57.78,36.03) ; U1.P9 v1(59.38,36.03) ; v1(70.89,32.8) 70.76,32.93 FL1.2 ; U1.P11 v1(61.78,36.03)
  BOTTOM w0.305: v1(59.38,36.03) 59.25,36.16 C135.1 ; C137.1 57.65,36.16 v1(57.78,36.03) ; v1(61.78,36.03) 61.91,36.16 C136.1
  BOTTOM w0.381: v1(70.89,32.8) 71.17,33.09 C134.1
VDDA_IO_1V8: length 9.9
  TOP w0.381: R467.1 51.01,33.98 v1(50.9,33.86) ; SW8.1 v1(32.07,24.19) ; U1.R8 v1(58.58,35.23) ; U1.R6 v1(56.98,35.23) ; U1.R11 v1(61.78,35.23)
  BOTTOM w0.305: v1(58.58,35.23) 58.45,35.36 C145.1 ; v1(56.98,35.23) 56.85,35.36 C143.1 ; C144.1 61.59,35.42 v1(61.78,35.23)
  BOTTOM w0.381: FL2.1 50.88,29.2 C140.1 51.12,31.04 51.12,32.11 C141.1 51.12,32.14 51.12,32.88 C142.1 51.01,32.98 51.01,33.75 v1(50.9,33.86)
VDDA_IO_3V3: length 25.2
  TOP w0.381: v1(64.76,23.87) 64.85,23.96 C329.1 ; v1(59.56,23.8) 59.5,23.85 C316.2 ; U72.16 v1(57.65,13.19) ; v1(52.7,23.87) 52.64,23.92 C330.2 ; C314.1 21.93,15.12 21.97,15.08 v1(21.97,14.45) U61.5 ; v1(51.99,12.98) 51.77,12.77 U73.16 ; U69.5 v1(32.89,14.45) 32.84,14.5 C315.1 ; U63.5 v1(27.81,14.45)
  BOTTOM w0.381: U63.5 v1(27.81,14.45) 27.76,14.5 C282.1 ; v1(65.59,17.45) FL7.2 65.59,15.61 v1(65.37,15.39) ; v1(38.08,15.74) C281.1 38.1,15.03 U65.5 ; U70.8 v1(59.56,23.8) ; v1(26.43,24.26) C284.1 27.87,24.26 27.88,24.26 U67.4 ; U61.5 v1(21.97,14.45) ; R409.1 v1(53.97,21.07) R406.1 ; U74.8 v1(64.76,23.87) ; U69.5 v1(32.89,14.45) 32.84,14.5 C315.1 ; U75.8 v1(52.7,23.87)
VDDC_1V2_XDS: length 16.9
  TOP w0.381: v1(25.94,88.72) 25.98,88.76 C259.1 C260.1 25.98,91.86 24.38,93.46 22.73,93.46 19.25,96.94 v1(19.25,97.6)
  BOTTOM w0.203: U52.115 19.43,96.11 19.25,96.29 C261.1 ; U52.87 v1(25.94,88.72)
  BOTTOM w0.381: C261.1 v1(19.25,97.6)
VDDIO: length 43.4
  TOP w0.203: J8.44 71.52,96.24 C225.1
  TOP w0.381: v1(88.43,63.31) 88.43,63.12 88.82,62.74 C217.1 ; C219.1 83.73,68.21 82.89,69.05 R225.1 R226.1 R231.2 R232.2 R230.2 ; v1(107.82,55.74) 107.82,55.75 R218.1 ; C226.1 v1(69.79,96.18)
  L03_SIG1 w0.381: v1(107.82,55.74) 105.21,55.74 103.09,57.86 102.26,57.86 v1(100.44,59.67)
  BOTTOM w0.254: U35.18 89.42,63.6 C216.1
  BOTTOM w0.305: C214.1 83.67,67.69 84.2,68.22 84.71,68.22 84.83,68.34 U35.30
  BOTTOM w0.381: C216.1 88.64,63.52 v1(88.43,63.31) ; v1(93.54,77.04) 93.9,77.4 R229.1 99.89,77.4 101.72,79.24 R216.2 ; v1(93.54,77.04) 94.24,76.34 94.24,75.56 93.85,75.17 R227.1 ; v1(93.54,77.04) R228.1 ; C214.1 v1(83.67,66.93) ; R233.2 85.85,62.42 v1(85.72,62.29) ; FL3.1 v1(100.44,59.67) ; R219.1 v1(107.82,55.74)
  vias: v1(70.35,96.76) v1(88.87,82.71)
VDDS_IO_1V8: length 8.2
  TOP w0.305: U1.L4 v1(55.38,38.43) ; U1.D6 v1(56.98,44.83) ; U1.T3 v1(54.58,34.43) ; U1.N15 v1(64.98,36.83) ; U1.E15 v1(64.98,44.03)
  TOP w0.381: C108.1 v1(68.62,32.82) ; U43.5 v1(42.29,30.67)
  L06_PWR2 w0.381: 55.62,38.72 55.38,38.48 v1(55.38,38.43) 55.38,38.33 55.55,38.16
  BOTTOM w0.305: v1(55.38,38.43) 55.51,38.56 C107.1 ; C106.1 56.87,44.72 v1(56.98,44.83) ; C105.1 64.87,44.14 v1(64.98,44.03) ; C109.1 54.47,34.54 v1(54.58,34.43)
  BOTTOM w0.381: v1(68.62,32.82) 68.98,32.46 C104.1
1588_SFD: length 86.7
  TOP w0.147: J8.38 73.3,95.04 v1(73.51,95.25)
  L08_SIG2 w0.091: v1(73.51,95.25) 73.51,94.88 73.76,94.63 73.76,92.8 73.3,92.34 73.03,92.34 72.4,91.71 70.29,91.71 69.48,90.91 69.48,90 67.05,87.57 67.05,87.22 65.25,85.42 65.25,78.44 62.7,75.89 62.7,64.63 62.04,63.97 58.98,63.97 57.92,62.9 52.29,62.9 50.76,64.43 49.55,64.43 49.02,64.96 42.52,64.96 40.19,62.63 40.19,58.24 40.21,58.22 40.21,58.1 40.46,57.85 40.57,57.85 41.41,57.01 42.36,57.01 42.92,56.45 42.92,55.51 43.43,54.99 43.43,52.03 41.84,50.44 41.84,48.21 44.14,45.91 v1(44.65,45.91)
  BOTTOM w0.147: v1(44.65,45.91) 45,46.27 45,46.4 45.83,47.23 R3881.2
ADC1_MUX_SEL: length 51.1
  L03_SIG1 w0.091: v1(54.96,66.54) 54.96,64.79 55.43,64.32 55.43,56.08 58.52,52.99 58.52,51.3 60.17,49.64 60.17,40.07 60.37,39.87 60.37,36.89 60.84,36.42 61.2,36.42 61.39,36.23 61.39,35.88 61.64,35.62 61.94,35.62 62.17,35.39 62.17,35.39 v1(62.17,28.08)
  BOTTOM w0.147: 63.37,26.88 63.09,27.16 62.55,27.16 62.17,27.54 v1(62.17,28.08) ; 63.37,26.88 63.37,25.96 63.76,25.57 U74.1 ; 63.37,26.88 63.66,27.17 R414.1 65.93,27.17 66.16,26.94 66.16,25.99 65.76,25.59 U74.5 ; U60.15 v1(54.96,66.54)
ADC2_MUX_SEL: length 54.1
  L03_SIG1 w0.091: v1(57.39,27.38) 58.21,28.2 58.78,28.2 59.82,29.23 59.82,30.97 60.17,31.32 60.17,39.79 59.97,39.99 59.97,49.21 58.29,50.89 58.29,52.8 54.44,56.64 54.44,62.62 54.04,63.03 v1(54.04,66.54)
  BOTTOM w0.147: U75.5 53.7,25.59 54.1,25.99 54.1,26.92 ; v1(54.04,66.54) 54.31,66.54 54.46,66.69 U60.16 ; 54.1,26.92 54.1,26.93 54.55,27.38 v1(57.39,27.38) ; 54.1,26.92 53.85,27.17 R415.1 51.87,27.17 51.3,26.61 51.3,25.98 51.7,25.59 U75.1
ADC3_MUX_SEL: length 58.4
  L03_SIG1 w0.091: v1(57.4,28.31) 58.37,29.28 58.37,30.68 59.97,32.27 59.97,39.71 59.77,39.91 59.77,49.03 58.03,50.76 58.03,52.68 53.93,56.78 53.93,62.36 53.56,62.73 53.56,66.76 54.69,67.88 58.3,67.88 v1(59.66,69.24)
  BOTTOM w0.147: 58.57,27.14 58.57,27.13 58.17,26.72 58.17,25.94 58.56,25.55 U70.1 ; 58.57,27.14 58.57,27.14 R405.1 60.85,27.14 61.13,26.85 61.13,26.09 60.56,25.51 U70.5 ; 58.57,27.14 v1(57.4,28.31) ; U60.6 v1(59.66,69.24)
ADC4_AIN0/ADC_CAL0/ADC_R0_AIN0: length 71.9
  TOP w0.147: U61.4 C306.1 22.92,15.67 v1(22.73,15.86) ; J15.25 v1(27.04,4.56)
  L03_SIG1 w0.091: v1(27.04,4.56) 26.41,3.93 21.37,3.93 20.59,4.71 20.59,9.11 22.44,10.96 22.44,14.27 22.73,14.56 v1(22.73,15.86)
  L08_SIG2 w0.091: v1(22.73,15.86) 22.73,13.75 23.82,12.66 23.82,9.18 24.88,8.12 24.88,6.54 25.53,5.9 26.62,5.9 27.4,5.11 29.37,5.11 31.2,6.95 34.07,6.95 34.67,7.54 35.12,7.54 35.88,8.3 35.88,9.69 40.19,14 40.19,15.69 43.81,19.31 48.04,19.31 v1(51.7,22.97)
  BOTTOM w0.147: U75.10 v1(51.7,22.97)
ADC4_AIN1/ADC_CAL1/ADC_R0_AIN1: length 84.5
  TOP w0.147: U61.6 20.93,13.72 C307.1 20.95,15.12 20.95,15.23 v1(20.32,15.86) ; J15.27 27.84,5.79 v1(27.04,6.59)
  L03_SIG1 w0.091: v1(20.32,15.86) 20.58,15.6 20.58,11.75 20.94,11.38 20.94,10.47 19.91,9.43 19.91,4.8 21.29,3.42 26.5,3.42 27.47,4.38 27.47,6.16 v1(27.04,6.59)
  L08_SIG2 w0.091: v1(20.32,15.86) 20.32,15.47 23.34,12.44 23.34,7.5 26.75,4.1 32.5,4.1 33.98,5.58 34.82,5.58 36.28,7.04 36.6,7.04 40.9,11.33 40.9,15.82 43.21,18.14 47.55,18.14 52.16,22.75 52.16,23.99 52.53,24.37 53.72,24.37 v1(54.22,23.87)
  BOTTOM w0.147: v1(54.22,23.87) 53.7,24.4 U75.6
ADC4_MUX_OE#: length 2
  TOP w0.147: U72.15 57,10.24 R407.1
ADC4_MUX_SEL: length 66.1
  TOP w0.147: v1(57.01,20.43) R408.1 57.01,19.17 57.65,18.54 U72.1
  L03_SIG1 w0.091: v1(57.01,20.43) 56.52,20.93 56.52,29.35 59.77,32.61 59.77,39.5 58.97,40.3 58.97,46.75 59.33,47.1 59.33,49.09 57.75,50.66 57.75,52.62 53.64,56.73 53.64,62.39 53.29,62.74 53.29,66.91 54.67,68.28 57.4,68.28 58.84,69.72 59.99,69.72 60.3,69.42 60.3,68.88 v1(59.66,68.24)
  BOTTOM w0.147: R406.2 57.01,20.44 v1(57.01,20.43) ; v1(59.66,68.24) 59.66,68.53 59.45,68.74 U60.7
ADC5_MUX_OE#: length 1.7
  TOP w0.147: U73.15 51.12,10.68 51.06,10.61 R410.1
ADC5_MUX_SEL: length 135.4
  TOP w0.147: v1(51.94,20.18) 51.9,20.14 R411.1 51.9,18.82 51.77,18.7 U73.1
  L08_SIG2 w0.091: v1(23.84,19.91) 24.22,19.53 24.22,18.84 23.97,18.59 18.55,18.59 14.32,22.83 14.32,27.29 15.12,28.09 15.12,32.87 17.21,34.97 17.21,36.86 15.05,39.02 15.05,53.65 19.44,58.04 19.44,60.6 25.96,67.13 28.01,67.13 29.21,68.32 47.57,68.32 50.38,71.14 52.12,71.14 52.54,70.72 53.76,70.72 54.24,70.24 54.24,69.03 55.14,68.12 56.87,68.12 v1(58.46,66.54)
  BOTTOM w0.147: v1(23.84,19.91) 23.84,20.36 24.27,20.8 35.4,20.8 36.73,22.13 49.92,22.13 50.97,21.07 R409.2 51.97,20.21 v1(51.94,20.18) ; U60.9 57.96,67.04 v1(58.46,66.54)
ADC_CAL0: length 41.5
  TOP w0.147: U1.U16 v1(65.78,33.63) ; U73.2 v1(51.12,18.78)
  L03_SIG1 w0.091: v1(65.78,33.63) 65.52,33.37 65.52,32.68 63.42,30.58 63.42,27.69 61.43,25.7 60.43,25.7 59.02,24.29 59.02,20.73 57.25,18.96 57.25,16.77 55.34,14.86 51.42,14.86 50.08,13.52 48.96,13.52 48.1,14.39 48.1,18.46 48.91,19.28 50.63,19.28 v1(51.12,18.78)
ADC_CAL0/ADC_R0_AIN0: length 10.8
  TOP w0.147: U73.4 v1(49.82,16.24)
  L08_SIG2 w0.091: v1(49.82,16.24) 49.82,19.21 52.7,22.08 v1(52.7,22.97)
  BOTTOM w0.147: U75.9 52.2,23.48 v1(52.7,22.97)
ADC_CAL1: length 12.2
  TOP w0.147: U1.T15 v1(64.98,34.43)
  L03_SIG1 w0.091: v1(60.58,26.28) 61.49,26.28 63.05,27.84 63.05,31.38 64.59,32.92 64.59,34.04 v1(64.98,34.43)
  BOTTOM w0.147: U70.4 60.06,25.76 v1(60.58,26.28)
ADC_CAL1/ADC_R0_AIN1: length 11.7
  L08_SIG2 w0.091: v1(61.87,24.42) 55.85,24.42 54.74,23.31 54.01,23.31 v1(53.46,23.86)
  BOTTOM w0.147: U70.6 60.56,24.32 60.86,24.03 61.48,24.03 v1(61.87,24.42) ; U75.7 53.2,24.13 v1(53.46,23.86)
ADC_CAL2: length 45.9
  TOP w0.147: U1.U17 v1(66.58,33.63)
  L03_SIG1 w0.091: v1(66.58,33.63) 66.58,32.6 64.16,30.18 64.16,27.39 61.04,24.27 61.04,23.77 59.39,22.13 59.39,20.57 59.9,20.06 59.9,18.91 55.49,14.5 51.57,14.5 50.11,13.04 v1(49.17,13.04)
  BOTTOM w0.147: v1(49.17,13.04) 48.49,13.72 46.7,13.72 45.76,14.66 43.95,14.66 J14.1 41.62,13.4 40.85,12.63 37.58,12.63 37.15,13.07 U65.4
ADC_CAL3: length 64.6
  TOP w0.147: U1.N17 v1(66.58,36.83)
  L03_SIG1 w0.091: v1(66.58,36.83) 69.38,36.83 71.32,34.89 71.32,32.33 69.12,30.13 69.12,28.5 69.52,28.11 69.52,26.44 67.74,24.67 67.74,23.36 64.64,20.25 64.64,19.38 62.16,16.91 61.64,16.91 60.72,15.99 60.72,13.22 55.98,8.48 51.03,8.48 50.53,8.98 47.41,8.98 46.31,10.09 44.53,10.09 41.65,12.97 41.65,14.89 J14.2
  BOTTOM w0.147: J14.2 39.83,15.94 39.05,15.16 U65.6
ADC_DAC-VREF: length 13.9
  TOP w0.381: SW7.2 37.15,25.04 37,24.89 v1(35.92,24.89)
  BOTTOM w0.381: v1(35.92,24.89) U67.12 33.38,24.89 33.14,24.65 ; U67.5 30.21,24.89 30.35,24.75 ; 30.35,24.75 31.83,24.75 31.84,24.76 33.03,24.76 33.14,24.65 ; 30.35,24.75 30.35,23.77 30.2,23.62 U67.3 ; U67.14 33.39,23.62 33.14,23.87 33.14,24.65
ADC_R0_AIN0: length 37.3
  TOP w0.147: U73.3 50.47,14.2 v1(51.18,13.5) ; U1.T18 v1(67.38,34.43)
  L03_SIG1 w0.091: v1(51.18,13.5) 51.71,14.03 55.81,14.03 56.22,14.44 58.33,14.44 59.09,15.21 59.09,16.3 61.24,18.44 61.24,19.67 61.69,20.12 61.69,22.65 62.19,23.15 63.46,23.15 66.83,26.52 66.83,31.02 68.13,32.32 68.13,33.69 v1(67.38,34.43)
ADC_R0_AIN1: length 14.6
  TOP w0.147: U1.T16 v1(65.78,34.43)
  L03_SIG1 w0.091: v1(60.33,23.79) 60.59,24.05 60.59,24.34 63.78,27.54 63.78,30.36 66.17,32.75 66.17,34.04 v1(65.78,34.43)
  BOTTOM w0.147: U70.7 60.06,24.09 60.33,23.83 v1(60.33,23.79)
ADC_R0_AIN2: length 27.1
  TOP w0.147: v1(57.86,14.98) 57.28,15.57 56.99,15.57 56.35,16.21 U72.3 ; U1.U18 v1(67.38,33.63)
  L03_SIG1 w0.091: v1(57.86,14.98) 57.86,15.59 60.68,18.41 60.68,22.37 61.84,23.53 62.4,23.53 64.33,25.46 64.7,25.46 64.7,25.51 65.22,26.03 65.22,28.93 65.64,29.35 65.64,30.49 67.77,32.62 67.77,33.24 v1(67.38,33.63)
ADC_R0_AIN3: length 28.8
  TOP w0.147: U1.T17 v1(66.58,34.43) ; v1(56.63,14.98) 55.28,14.98 54.4,15.86 U72.6
  L03_SIG1 w0.091: v1(56.63,14.98) 60.31,18.66 60.31,22.52 61.69,23.9 62.24,23.9 64.33,25.99 64.33,26.9 64.57,27.14 64.57,28.87 65.26,29.55 65.26,30.66 66.97,32.37 66.97,34.04 v1(66.58,34.43)
ADC_R1_AIN0: length 37.8
  TOP w0.147: U73.6 v1(48.52,14.85) ; U1.R16 v1(65.78,35.23)
  L03_SIG1 w0.091: v1(48.52,14.85) 48.52,14.47 49.09,13.91 49.94,13.91 51.33,15.3 55.25,15.3 56.88,16.92 56.88,19.11 57.8,20.04 57.8,21.16 57.25,21.72 57.25,24.25 58.03,25.04 59.13,25.04 60.07,25.97 60.07,26.52 60.48,26.93 61.63,26.93 62.6,27.9 62.6,31.57 63.79,32.77 63.79,34.59 64.04,34.84 65.39,34.84 v1(65.78,35.23)
ADC_R1_AIN1: length 24.5
  TOP w0.147: U1.R18 v1(67.38,35.23)
  L03_SIG1 w0.091: v1(67.38,35.23) 68.45,35.23 69.51,34.17 69.51,32.29 67.6,30.38 67.6,26.18 66.61,25.2 66.61,23.78 65.16,22.33 v1(62.48,22.33)
  BOTTOM w0.147: v1(62.48,22.33) 62.16,22.65 59.68,22.65 59.06,23.27 U70.9
ADC_R1_AIN2: length 36.4
  TOP w0.147: U1.P18 v1(67.38,36.03) ; U72.10 53.75,12.75 53.63,12.87 v1(53.63,12.94)
  L03_SIG1 w0.091: v1(67.38,36.03) 67.79,35.62 69.4,35.62 70.08,34.94 70.08,34.46 69.88,34.26 69.88,32.03 67.97,30.12 67.97,25.98 67.01,25.02 67.01,23.66 63.9,20.56 63.9,19.77 61.85,17.72 61.25,17.72 59.5,15.97 59.5,15.03 58.49,14.01 56.54,14.01 56.11,13.58 54.27,13.58 v1(53.63,12.94)
ADC_R1_AIN3: length 38
  TOP w0.147: U72.13 55.7,10.49 v1(55.64,10.43) ; U1.P17 v1(66.58,36.03)
  L03_SIG1 w0.091: v1(55.64,10.43) 59.88,14.67 59.88,15.82 61.4,17.34 62.01,17.34 64.27,19.6 64.27,20.41 67.37,23.51 67.37,24.83 69.08,26.54 69.08,27.93 68.72,28.28 68.72,30.32 70.25,31.84 70.25,33.63 70.53,33.91 70.53,35.07 69.57,36.03 68.17,36.03 67.78,36.42 66.97,36.42 v1(66.58,36.03)
ADC_VREF1: length 6.3
  TOP w0.381: SW9.3 31.06,22.71 v1(31.33,22.99)
  BOTTOM w0.381: U67.2 30.23,22.99 ; 30.23,22.99 30.37,22.84 30.37,22.5 30.23,22.35 U67.1 ; 30.23,22.99 v1(31.33,22.99)
ADC_VREF2: length 9.7
  TOP w0.381: SW9.6 27.36,22.24 27.55,22.43 v1(27.55,26.16)
  BOTTOM w0.381: v1(27.55,26.16) U67.7 30.21,26.16 30.21,26.16 30.21,25.54 30.2,25.53 U67.6
ADC_VREF3: length 6.8
  TOP w0.381: SW13.3 35.19,22.26 v1(35.92,22.99)
  BOTTOM w0.381: v1(35.92,22.99) U67.15 33.39,22.99 33.27,22.86 33.27,22.49 33.42,22.34 34.43,22.34 U67.16
ADC_VREFHI_G0_G1: length 1.8
  TOP w0.147: SW9.2 R401.2
ADC_VREFHI_G0_G1_R: length 50.8
  TOP w0.147: U1.V10 v1(60.98,32.83) ; U1.V14 63.78,32.75 63.69,32.66 C287.1 C286.1 63.69,29.7 C285.1 64.63,29.61 v1(64.67,29.64) ; v1(40.99,18.16) 40.99,17.48 38.79,15.28 36.51,15.28 33.48,18.31 R401.1
  L08_SIG2 w0.091: v1(40.99,18.16) 43.05,20.21 47.54,20.21 52.75,25.43 61.53,25.43 63.9,27.8 63.9,28.88 v1(64.67,29.64)
  BOTTOM w0.147: v1(64.67,29.64) 63.05,29.64 60.98,31.71 v1(60.98,32.83)
ADC_VREFHI_G2: length 1.8
  TOP w0.147: SW9.5 R402.2
ADC_VREFHI_G2_R: length 55.8
  TOP w0.147: R402.1 v1(24.51,20.27) ; v1(57.41,29.29) 57.35,29.36 C288.1 57.53,30.19 C289.1 57.53,31.62 57.38,31.77 U1.V6
  L08_SIG2 w0.091: v1(24.51,20.27) 26.07,18.71 26.07,15.13 25.56,14.62 25.56,12.29 26.46,11.39 33.65,11.39 36.03,13.76 36.03,16.41 37.13,17.52 37.13,17.84 45.84,26.55 49.15,26.55 50.9,28.31 50.9,28.39 51.55,29.04 54.6,29.04 55.32,29.75 56.95,29.75 v1(57.41,29.29)
ADC_VREFHI_G3: length 2
  TOP w0.147: SW13.2 R1648.1
ADC_VREFHI_G3_R: length 38.9
  TOP w0.147: R1648.2 39.45,16.58 v1(40.13,17.26) ; v1(66.33,29.11) C349.1 66.09,30.25 C350.1 66.09,33.14 U1.V17
  L08_SIG2 w0.091: v1(40.13,17.26) 41.01,17.26 43.55,19.8 47.49,19.8 52.71,25.03 64.03,25.03 65.19,26.18 65.19,27.97 v1(66.33,29.11)
AM263_ADC_VREFLO_1: length 8.3
  TOP w0.381: U1.V13 63.13,33.08 C287.2 ; R404.2 61.49,29.61 C285.2 63.13,29.94 C286.2 C287.2 ; C287.2 62.18,31.31 61.8,31.69 61.8,32.81 U1.V11
AM263_ADC_VREFLO_2: length 4.6
  TOP w0.381: U1.V7 58.09,33.14 58.09,33.09 58.05,33.05 58.05,31.78 58.09,31.74 C289.2 58.09,30.25 C288.2 58.33,28.95 R403.2
AM263_ADC_VREFLO_3: length 4.7
  TOP w0.381: U1.V16 65.53,33.08 C350.2 65.53,30.19 C349.2 65.4,29.96 R1649.2
AM263_DAC_VREF: length 7.9
  TOP w0.381: SW8.3 35.28,27.69 35.92,27.05 v1(35.92,26.16)
  BOTTOM w0.381: U67.11 33.26,25.53 33.26,26.14 33.28,26.16 U67.10 v1(35.92,26.16)
AM263_DAC_VREF0: length 43.7
  TOP w0.381: C279.1 32,27.22 32.05,27.17 v1(32.51,27.17) ; C279.1 29.49,26.24 29.8,25.94 SW8.2 ; C279.1 C280.1 ; U1.T6 v1(56.98,34.43) ; U1.T13 v1(63.38,34.43)
  L08_SIG2 w0.091: v1(63.38,34.43) 62.99,34.82 62.99,35.37 62.74,35.62 58.42,35.62 58.17,35.37 58.17,35.07 57.94,34.84 57.39,34.84 v1(56.98,34.43) 56.59,34.04 53.3,34.04 52.62,33.36 49.85,33.36 48.51,32.02 41.65,32.02 40.13,30.49 35.83,30.49 v1(32.51,27.17)
BOOST_COMP: length 3.7
  TOP w0.203: C380.1 93.24,29.25 93.46,29.03 R552.1 92.98,28.51 92.08,27.61 U5.4
BOOST_EN: length 2.8
  TOP w0.147: U5.7 88.63,27.61 88.26,27.98 v1(88.26,28.54) 88.26,28.53 R20.2
  BOTTOM w0.147: v1(88.26,28.54) 88.26,28.53 R20.2
BOOST_FSW: length 1.8
  TOP w0.203: U5.1 91.6,26.11 91.77,25.94 R550.1
BOOST_ILIM: length 1.5
  TOP w0.147: U5.8 R551.1
BOOTMODE_TA_I2C_SCL: length 39.4
  TOP w0.147: v1(63.24,78.47) 63.24,77.89 R286.2 62.47,78.31 U47.12
  L08_SIG2 w0.091: v1(64.13,98.54) 63.08,97.49 63.08,91.18 62.3,90.4 62.3,83.87 62.94,83.24 62.94,81.77 63.24,81.47 v1(63.24,78.47) 62.32,78.47 61.11,79.68 58.6,79.68 56.2,82.08 52.19,82.08 v1(51.76,82.51)
  BOTTOM w0.147: R303.1 v1(64.13,98.54) ; R361.2 v1(51.76,82.51)
BOOTMODE_TA_I2C_SDA: length 40.8
  TOP w0.147: U47.13 64.45,79.98 64.72,79.71 R287.2 v1(64,79.09)
  L08_SIG2 w0.091: v1(66.16,98.54) 65.25,97.63 65.25,90.54 63.79,89.08 63.79,82.45 64,82.25 v1(64,79.09) 64,78.58 63.35,77.93 62.14,77.93 60.65,79.42 58.48,79.42 56.06,81.84 51.53,81.84 v1(50.92,81.24)
  BOTTOM w0.147: R305.1 v1(66.16,98.54) ; R362.2 v1(50.92,81.24)
BOOTMODE_XDS_I2C_SCL: length 18.6
  L08_SIG2 w0.091: v1(34.79,95.27) 36.06,94 36.06,87.52 v1(40.46,83.12)
  BOTTOM w0.147: v1(40.46,83.12) R360.2 U56.3 ; v1(34.79,95.27) 35.16,94.91 U52.49
BOOTMODE_XDS_I2C_SDA: length 18.8
  L08_SIG2 w0.091: v1(34.79,94.22) 35.43,93.59 35.43,87.36 40.46,82.33 v1(40.46,81.85)
  BOTTOM w0.147: U52.50 35.08,94.51 v1(34.79,94.22) ; v1(40.46,81.85) R359.2 U56.2
BOOTMODEON: length 12.1
  BOTTOM w0.147: 67.59,85.47 67.13,85.01 66.48,85.01 66.15,85.34 U48.1 ; 67.59,85.47 67.96,85.47 68.3,85.82 68.3,89.1 69.18,89.99 R329.1 68.06,92.28 R330.2 ; 67.59,85.47 67.16,85.9 U48.16
C_A5_CC1: length 10.7
  TOP w0.147: v1(107.58,18.91) 107.58,18.8 107.31,18.53 J1.A5
  BOTTOM w0.147: U17.1 101.6,14.96 102.55,15.91 102.55,16.81 103.66,17.91 105.19,17.91 106.19,18.91 v1(107.58,18.91) 107.58,18.39 D1.1
C_B5_CC2: length 13.3
  TOP w0.147: J1.B5 107.79,20.28 107.58,20.07 v1(107.58,20.05)
  BOTTOM w0.147: D2.1 107.58,20.71 v1(107.58,20.05) 108.45,19.18 108.45,17.35 108.07,16.97 105.57,16.97 105.31,17.23 104.45,17.23 102,14.77 U17.2
CLK_BUF_EN: length 79.9
  TOP w0.147: R276.1 17.77,35.49 18.12,35.84 U41.2 20.66,35.84 20.75,35.93 v1(21.2,35.93)
  L08_SIG2 w0.091: v1(59.94,72.16) 60.4,71.7 60.4,68.3 59.7,67.61 59.7,66.08 58.19,64.57 51.92,64.57 50.43,66.07 41.7,66.07 41.11,65.47 39.7,65.47 38.96,64.73 27.1,64.73 22.86,60.5 22.86,58.41 23.17,58.11 23.17,55.45 23.43,55.19 23.43,54.11 19.66,50.34 19.66,42.06 21.2,40.52 v1(21.2,35.93)
  BOTTOM w0.147: U60.2 59.33,71.24 59.52,71.43 59.52,71.73 v1(59.94,72.16)
CLK_OUT2: length 7.1
  BOTTOM w0.147: TP62.1 89.15,77.85 89.15,76.22 88.96,76.04 88.96,74.26 87.91,73.21 87.91,72.82 87.92,72.81 U35.40
CLOCKOUT0: length 55.9
  TOP w0.147: U1.M2 v1(53.78,37.63) ; R271.1 v1(16.23,38.98)
  L08_SIG2 w0.091: v1(53.78,37.63) 51.4,37.63 49.56,35.79 49.56,35.14 48.31,33.88 37.36,33.88 33.21,29.73 26.15,29.73 22.64,26.22 19.76,26.22 17.89,28.09 17.89,37.32 v1(16.23,38.98)
DIR1: length 4.2
  BOTTOM w0.147: U48.5 64.15,85.9 63.85,85.6 63.85,85.23 64,85.08 ; 64,85.08 64.77,85.08 64.95,85.26 U48.4 ; 64,85.08 63.37,84.44 R322.1
EEPROM_A1: length 1.7
  BOTTOM w0.147: U28.2 R168.2
EEPROM_A2: length 1.7
  BOTTOM w0.147: U28.3 R169.2
EEPROM_WP: length 2.8
  BOTTOM w0.147: R170.2 R167.2 U28.7
EPWM7_A: length 11.3
  TOP w0.147: U1.F4 v1(55.38,43.23)
  BOTTOM w0.114: 52.58,43.7 52.64,43.63 54.98,43.63 v1(55.38,43.23)
  BOTTOM w0.147: 52.58,43.7 52.32,43.96 52.32,45.05 51.89,45.48 51.89,46.32 51.56,46.64 50.98,46.64 50.7,46.37 49.53,46.37 49.28,46.62 R3880.1 R3881.1
EPWM7_B: length 11
  TOP w0.147: U1.F1 52.98,43.23 52.83,43.23 51.97,44.08 51.97,46.45 51.41,47.01 48.09,47.01 47.74,47.36 R3877.1 R3876.1
EPWM10_B: length 36.3
  TOP w0.147: R3879.1 35.04,37.39 35.44,37.79 v1(36.68,37.79) ; U1.J3 v1(54.58,40.83)
  L08_SIG2 w0.091: v1(50.94,45.7) 50.94,44.35 49.2,42.61 46.91,42.61 44.87,40.57 42.88,40.57 42.11,39.8 39.76,39.8 38.56,41 37.92,41 37.24,41.68 35.87,41.68 35.08,40.9 35.08,38.64 35.93,37.79 v1(36.68,37.79)
  BOTTOM w0.147: R193.1 50.74,45.5 v1(50.94,45.7) 51.63,45.01 51.63,44.12 52,43.76 52,42.68 52.76,41.91 52.76,41.01 53.36,40.41 54.17,40.41 v1(54.58,40.83)
EPWM11_A: length 6.7
  TOP w0.147: R3865.1 R190.1 50.75,45.13 51.38,44.5 51.38,43.99 52.32,43.05 52.32,42.29 U1.H1
ETH_EEPROM_A0: length 2.4
  TOP w0.147: J8.47 75.63,97.04 76.32,97.73 R3875.1
ETH_EEPROM_A2: length 1.7
  TOP w0.147: J8.37 v1(74.31,95.04)
  BOTTOM w0.147: R3874.1 75.03,95.04 v1(74.31,95.04)
ETH_LED1: length 3.2
  TOP w0.147: LD11.1 v1(68.07,75.3)
  BOTTOM w0.147: U59.3 68.78,75.04 68.52,75.3 v1(68.07,75.3)
ETH_LED2: length 3.3
  TOP w0.147: LD12.1 v1(68.07,73.27)
  BOTTOM w0.147: U59.4 68.58,73.77 v1(68.07,73.27)
ETH_LED3: length 3.9
  TOP w0.147: LD13.1 v1(68.07,71.23)
  BOTTOM w0.147: U59.5 68.83,72.5 68.07,71.74 v1(68.07,71.23)
ETH_LED4: length 4.6
  TOP w0.147: LD14.1 v1(68.07,69.2)
  BOTTOM w0.147: v1(68.07,69.2) 68.07,70.47 68.83,71.23 U59.6
ETH_LED5: length 4.7
  TOP w0.147: LD15.1 v1(66.54,69.2)
  BOTTOM w0.147: v1(66.54,69.2) 66.54,70.22 65.53,71.23 U59.11
ETH_LED6: length 4.2
  TOP w0.147: LD16.1 v1(66.54,71.23)
  BOTTOM w0.147: U59.12 65.91,72.5 66.54,71.87 v1(66.54,71.23)
ETH_LED7: length 3.5
  TOP w0.147: LD17.1 v1(66.54,73.27)
  BOTTOM w0.147: v1(66.54,73.27) 66.04,73.77 U59.13
ETH_LED8: length 3.4
  TOP w0.147: LD18.1 v1(66.54,75.3)
  BOTTOM w0.147: v1(66.54,75.3) 66.09,75.3 65.83,75.04 U59.14
EXT_VMON1: length 69.2
  TOP w0.147: TP85.1 85.67,49.76 85.93,50.02 R53.2 R55.2 87.15,49.57 87.35,49.37 v1(87.8,49.37) ; v1(105.69,35.28) 105.37,35.6 105.37,35.6 105.19,35.78 U7.16
  L03_SIG1 w0.091: v1(110.46,58.38) 112.24,56.59 112.24,53.94 113.56,52.62 113.56,45.77 112.84,45.05 111.98,45.05 111.14,44.2 111.14,39.16 108.84,36.85 106.72,36.85 106.22,36.36 106.22,35.81 v1(105.69,35.28)
  L08_SIG2 w0.091: v1(110.46,58.38) 109.7,57.63 99.6,57.63 96.79,60.43 v1(96.79,61.09)
  BOTTOM w0.147: v1(87.8,49.37) 90.02,49.37 92.24,51.59 92.24,56.19 95.2,59.15 95.2,59.96 96.34,61.09 v1(96.79,61.09)
EXT_VMON2: length 138.5
  TOP w0.147: v1(102.19,36.04) U7.10 ; v1(73.27,88.13) 72.99,87.84 J8.2
  L08_SIG2 w0.091: v1(73.27,88.13) 73.77,88.62 73.77,92.4 75.09,93.73 75.09,98.15 76.32,99.38 77.56,99.38 78.4,100.21 78.4,102.39 79.81,103.81 81.65,103.81 82.5,104.66 84.83,104.66 85.31,105.14 85.31,105.72 86.47,106.88 88.9,106.88 89.54,107.52 99.8,107.52 103.37,103.94 103.37,92.9 105.13,91.15 105.13,84.78 103.95,83.6 101.86,83.6 96.13,77.87 92.73,77.87 92.28,78.31 90.94,78.31 90.19,77.57 90.19,76.44 94.32,72.31 94.32,62.1 93.7,61.48 93.7,59.44 94.83,58.31 94.83,44.37 93.52,43.06 93.52,38.1 94.08,37.54 94.74,37.54 95.43,36.85 101.38,36.85 v1(102.19,36.04)
FSI_MUX_OE#: length 2.2
  BOTTOM w0.147: R206.1 36.34,29.79 35.76,29.22 U33.15
FSI_MUX_SEL: length 89.1
  L08_SIG2 w0.091: v1(60.13,67.43) 60.13,66.13 58.3,64.3 51.77,64.3 50.32,65.76 41.9,65.76 41.31,65.17 39.88,65.17 39.15,64.44 30.28,64.44 28.96,63.12 27.93,63.12 26.9,62.1 24.83,62.1 23.29,60.56 23.29,58.92 24.93,57.29 24.93,39.16 28.46,35.63 28.46,34.65 27.71,33.9 v1(26.79,33.9)
  BOTTOM w0.147: v1(26.79,33.9) 29.89,33.9 30.68,33.11 30.68,29.01 30.36,28.69 30.04,28.69 29.92,28.57 U33.1 27.77,28.57 27.76,28.58 R204.2 R205.1 ; U60.5 59.87,69.74 60.13,69.48 v1(60.13,67.43)
FSIRX2_CLK: length 20.2
  BOTTOM w0.147: J6.1 12.79,29.92 14.45,29.92 15.14,30.61 15.14,31.56 16.49,32.91 26,32.91 27.09,31.82 U33.6
FSIRX2_CLK/MCAN4_TXD: length 34.9
  TOP w0.147: U1.J2 v1(53.78,40.83)
  L08_SIG2 w0.091: v1(27.43,32.47) 27.43,31.94 29.45,29.91 33.13,29.91 37.29,34.07 48.24,34.07 49.23,35.07 49.23,35.74 52.95,39.46 52.95,40 v1(53.78,40.83)
  BOTTOM w0.147: U33.7 v1(27.43,32.47)
FSIRX2_DATA0: length 19.6
  TOP w0.147: J6.5 17.78,29.83 23.49,29.83 25.14,31.48 32.05,31.48 v1(33.04,32.47)
  BOTTOM w0.147: U33.10 v1(33.04,32.47)
FSIRX2_DATA0/MCAN5_RXD: length 30
  TOP w0.147: U1.G4 v1(55.38,42.43)
  L08_SIG2 w0.091: v1(55.38,42.43) 54.99,42.82 52.82,42.82 52.08,42.08 52.08,40.14 48.76,36.82 48.01,36.82 46.25,35.07 42.47,35.07 42.07,35.47 39.91,35.47 39.15,34.71 34.49,34.71 v1(33.01,33.23)
  BOTTOM w0.147: U33.9 33.11,33.12 33.02,33.21 33.02,33.23 v1(33.01,33.23)
FSIRX2_DATA1: length 17.7
  BOTTOM w0.147: J6.7 20.22,27.38 29.98,27.38 31.49,28.9 31.49,29.83 32.18,30.52 U33.13
FSIRX2_DATA1/MCAN5_TXD: length 30.6
  L08_SIG2 w0.091: v1(48.51,45.5) 47.72,44.7 47.72,43.8 44.69,40.77 39.57,40.77 39.05,41.29 37.95,41.29 37.3,41.94 35.39,41.94 34.68,41.24 34.68,35.77 32.4,33.49 32.4,31.79 v1(33.02,31.17)
  BOTTOM w0.147: U33.12 v1(33.02,31.17) ; R193.2 v1(48.51,45.5)
FSITX2_CLK: length 58.6
  TOP w0.147: U1.G3 v1(54.58,42.43)
  L03_SIG1 w0.091: v1(20.7,26.66) 13.93,26.66 12.69,27.91 12.69,29.84 J6.2
  L08_SIG2 w0.091: v1(20.7,26.66) 22.75,26.66 24.14,28.04 24.14,30.53 26.69,33.08 27.68,33.08 28.09,32.67 28.09,32.05 30.04,30.1 33.06,30.1 37.21,34.25 47.43,34.25 48.08,34.9 48.08,35.22 48.33,35.47 48.58,35.47 52.61,39.5 52.61,41.01 53.64,42.04 54.19,42.04 v1(54.58,42.43)
FSITX2_DATA0: length 54.4
  TOP w0.147: U1.H2 v1(53.78,41.63)
  L08_SIG2 w0.091: v1(53.78,41.63) 54.19,41.22 54.19,40.59 54.97,39.81 54.97,36.59 54.81,36.43 54.25,36.43 54.17,36.52 53.63,36.52 52.11,35 49.68,35 48.39,33.7 37.44,33.7 27.09,23.35 22.37,23.35 17.66,28.07 17.66,29.95 J6.6
FSITX2_DATA1: length 11.3
  BOTTOM w0.147: J6.8 20.26,32.32 25.32,32.32 27.77,29.87 U33.3
FSITX2_DATA1/MCAN4_RXD: length 31.2
  TOP w0.147: U1.G1 v1(52.98,42.43)
  L08_SIG2 w0.091: v1(52.98,42.43) 52.35,41.8 52.35,39.5 48.69,35.83 47.81,35.83 47.19,35.22 47.19,34.8 46.83,34.43 37.14,34.43 33.23,30.52 v1(30.22,30.52)
  BOTTOM w0.147: U33.4 v1(30.22,30.52)
GPIO_ICSSM1_RST: length 17
  TOP w0.147: U1.N18 68.67,35.54 70.31,35.54 71.8,34.05 75.16,34.05 78.34,37.24 R217.1 U36.1
GPIO_ICSSM2_RST: length 92.2
  TOP w0.147: v1(67.38,37.63) U1.M18
  BOTTOM w0.147: U39.1 R265.1 71.01,99.37 70.53,98.89 70.53,97.74 69.28,96.5 69.28,95.88 69.61,95.54 69.61,95.09 70.22,94.49 70.22,92.85 69.82,92.44 69.82,90.2 68.63,89.02 68.63,85.7 68.15,85.22 68.15,84.67 67.45,83.97 67.45,81.84 66.9,81.29 64.57,81.29 62.15,78.87 62.15,72.13 60.61,70.58 60.61,67.53 61.48,66.66 64.85,66.66 65.06,66.45 65.06,64.3 63.02,62.26 63.02,57.03 67.89,52.16 70.97,52.16 71.73,51.4 71.73,49.9 71.49,49.66 71.49,47.79 71.96,47.32 74.27,47.32 74.73,46.86 75.95,46.86 76.16,46.65 76.16,46 75.93,45.77 70.03,45.77 69.19,44.94 69.19,43.02 67.87,41.7 67.87,38.12 v1(67.38,37.63)
GPIO_USD_PWR_EN: length 54
  TOP w0.147: v1(18.12,53.42) R125.1 17.86,52.31 U22.2
  L08_SIG2 w0.091: v1(59.02,67.56) 59.02,66.14 57.96,65.09 52.59,65.09 50.96,66.71 41.31,66.71 40.75,66.15 39.4,66.15 38.58,65.34 26.79,65.34 21.74,60.28 21.74,57.64 18.12,54.02 v1(18.12,53.42)
  BOTTOM w0.147: v1(59.02,67.56) 58.76,67.82 U60.8
HSEC_5V0: length 37.9
  TOP w0.381: TP81.1 103.65,8.67 v1(103.65,9.02)
  BOTTOM w0.381: v1(66.29,5.45) 67.04,4.7 J15.118 ; J15.98 59.04,4.74 v1(59.72,5.43) ; C332.1 111.21,8.76 v1(111.39,8.57) C333.1 111.23,7.7 111.23,4.59 112.04,3.78 J15.180 ; v1(97.66,24.75) 95.68,24.75 95.26,24.33 R13.1 R12.1 ; J15.48 v1(35.84,5.58) ; J15.84 53.44,4.19 53.2,4.43 53.2,5.33 v1(53.44,5.58) ; J15.112 64.64,3.82 64.12,4.34 64.12,5.05 v1(64.64,5.58) ; v1(103.65,9.02) C334.1 103.65,7.29 103.24,6.88 J15.158
  vias: v1(90.65,19.29) v1(90.65,18.4) v1(93.54,18.88)
HSEC_ADC0_AIN0: length 8.8
  TOP w0.147: U1.V15 v1(64.98,32.83)
  L08_SIG2 w0.091: v1(63.88,26.36) 64.53,27.01 64.53,28.49 65.24,29.2 65.24,32.57 v1(64.98,32.83)
  BOTTOM w0.147: U74.2 64.26,25.97 v1(63.88,26.36)
HSEC_ADC0_AIN0/DAC_OUT: length 73.3
  TOP w0.147: v1(21.02,12.18) U61.1 21.02,9.94 C290.1 21.06,8.16 20.64,7.74 J15.9
  L08_SIG2 w0.091: v1(63.5,23.82) 63.23,23.55 63.23,22.42 55.31,14.5 50.74,14.5 50.23,13.99 48.23,13.99 47.35,14.87 46.59,14.87 46.23,14.51 44.57,14.51 44.17,14.12 44.17,12.61 38.73,7.16 38.73,4.45 37.54,3.25 23.3,3.25 21.02,5.54 v1(21.02,12.18)
  BOTTOM w0.147: U74.10 63.76,24.38 63.5,24.12 v1(63.5,23.82)
HSEC_ADC0_AIN1: length 10.1
  TOP w0.147: U1.U15 v1(64.98,33.63)
  L08_SIG2 w0.091: v1(65.65,26.36) 66.75,27.46 66.75,29.55 65.67,30.64 65.67,32.94 v1(64.98,33.63)
  BOTTOM w0.147: v1(65.65,26.36) 65.26,25.96 U74.4
HSEC_ADC0_AIN1/DAC_OUT: length 73.4
  TOP w0.147: J15.11 21.44,4.07 21.66,4.3 21.66,7.58 22.87,8.8 C291.1 22.92,9.94 U61.3 v1(22.92,12.18)
  L08_SIG2 w0.091: v1(65.91,23.82) 65.43,24.3 62.74,24.3 60.46,22.02 59.84,22.02 58.57,20.74 58.57,18.28 55.6,15.31 46.51,15.31 46.08,14.87 44.41,14.87 43.79,14.24 43.79,12.74 37.74,6.7 37.74,6.18 37.87,6.06 37.87,5.18 36.32,3.64 25.53,3.64 24.73,4.43 24.73,5.43 22.92,7.25 v1(22.92,12.18)
  BOTTOM w0.147: U74.6 65.76,24.09 65.91,23.94 v1(65.91,23.82)
HSEC_ADC0_AIN2: length 82.6
  TOP w0.147: v1(22.24,6.59) 23.06,5.77 23.06,4.09 23.04,4.07 J15.15 ; U1.T14 v1(64.18,34.43)
  L03_SIG1 w0.091: v1(23.49,15.86) 23.49,15.49 23.4,15.4 23.4,9.92 22.24,8.76 v1(22.24,6.59)
  L08_SIG2 w0.091: v1(23.49,15.86) 23.49,15.49 23.47,15.47 23.47,13.57 24.26,12.78 24.26,9.67 26.91,7.02 27.38,7.02 28.24,6.16 28.94,6.16 30.9,8.12 33.73,8.12 39.49,13.88 39.49,17.26 42.9,20.67 47.48,20.67 52.6,25.79 61.18,25.79 63,27.62 63,29.06 64.57,30.63 64.57,34.04 v1(64.18,34.43)
  BOTTOM w0.147: v1(23.49,15.86) 22.87,15.25 C292.1 22.87,14.4 22.92,14.35 U62.6
HSEC_ADC0_AIN3: length 86.6
  TOP w0.147: J15.17 v1(23.84,4.56) ; U1.U14 v1(64.18,33.63)
  L03_SIG1 w0.091: v1(23.84,4.56) 23.47,4.56 22.95,5.07 22.95,7.97 24.32,9.34 24.32,15.91 23.81,16.43 21.64,16.43 v1(21.08,15.86)
  L08_SIG2 w0.091: v1(21.08,15.86) 21.5,16.29 23.67,16.29 24.13,15.83 24.13,14.71 24.71,14.13 24.71,11.68 25.45,10.93 25.45,9 25.49,8.95 26.41,8.03 27.22,8.03 28.14,7.11 29.02,7.11 30.43,8.52 33.61,8.52 38.96,13.87 38.96,17.25 42.91,21.19 47.47,21.19 52.24,25.96 52.24,26.5 52.52,26.78 55.65,26.78 55.84,26.59 58.38,26.59 58.63,26.84 60.09,26.84 64.18,30.93 v1(64.18,33.63)
  BOTTOM w0.147: v1(21.08,15.86) 20.93,15.72 C293.1 20.93,14.51 21.02,14.42 U62.4
HSEC_ADC0_AIN4: length 77.6
  TOP w0.147: v1(25.14,15.99) 25.92,15.99 26.77,15.14 C294.1 26.77,14.51 26.86,14.42 U63.6 ; U1.U13 v1(63.38,33.63) ; J15.21 v1(25.44,4.56)
  L03_SIG1 w0.091: v1(25.44,4.56) 24.88,5.12 23.69,5.12 23.41,5.4 23.41,7.78 25.1,9.47 25.11,9.47 25.36,9.72 25.36,9.73 25.44,9.81 25.44,15.69 v1(25.14,15.99)
  L08_SIG2 w0.091: v1(63.38,33.63) 63.38,31.64 60.99,29.25 60.59,29.25 59.23,27.88 55.01,27.88 54.68,27.54 51.67,27.54 49.72,25.6 45.92,25.6 38.04,17.72 38.04,17.14 37.52,16.62 37.52,14.23 32.76,9.47 29.82,9.47 28.94,8.58 28.54,8.58 25.18,11.94 25.18,14.3 24.59,14.9 24.59,15.44 v1(25.14,15.99)
HSEC_ADC0_AIN5: length 69.5
  TOP w0.147: v1(28.57,15.86) 28.57,15.29 C295.1 U63.4 ; v1(25.44,6.59) 26.24,5.79 J15.23 ; U1.R14 v1(64.18,35.23)
  L03_SIG1 w0.091: v1(28.57,15.86) 27.28,14.58 27.28,9.23 26.3,8.25 25.48,8.25 25.01,7.78 25.01,7.02 v1(25.44,6.59)
  L08_SIG2 w0.091: v1(28.57,15.86) 28.13,16.31 28.13,23.39 35.61,30.87 39.94,30.87 41.54,32.47 48.3,32.47 50.16,34.33 52.82,34.33 53.33,34.84 55.62,34.84 55.79,35.02 55.79,36.19 56.02,36.42 63.59,36.42 63.79,36.22 63.79,35.62 v1(64.18,35.23)
HSEC_ADC1_AIN0: length 62.7
  TOP w0.147: U1.T11 v1(61.78,34.43)
  L03_SIG1 w0.091: v1(21.09,4.81) 21.09,8.89 v1(22.09,9.89)
  L08_SIG2 w0.091: v1(30.6,12.56) 31.71,12.56 35.24,16.09 35.24,16.94 36.21,17.9 36.21,20.17 39.64,23.6 41.78,23.6 45.68,27.5 48.24,27.5 50.63,29.89 53.75,29.89 54.35,29.89 54.99,30.52 59.74,30.52 59.91,30.7 62.17,32.95 62.17,34.04 v1(61.78,34.43)
  BOTTOM w0.147: v1(22.09,9.89) C296.1 22.92,9.94 U62.1 22.92,11.4 23.39,11.87 25.22,11.87 26.03,12.69 30.02,12.69 30.15,12.56 v1(30.6,12.56) ; v1(21.09,4.81) 21.44,4.47 J15.12
HSEC_ADC1_AIN1: length 67.3
  TOP w0.147: U1.U11 v1(61.78,33.63)
  L08_SIG2 w0.091: v1(26.03,14.34) 26.37,14 26.37,12 26.62,11.75 27.98,11.75 28.23,12 28.23,13.46 31.06,16.29 33.92,16.29 35.75,18.12 35.75,20.23 39.73,24.2 41.83,24.2 45.63,28 48.22,28 50.47,30.25 53.9,30.25 54.2,30.25 54.83,30.89 59.58,30.89 61.78,33.08 v1(61.78,33.63)
  BOTTOM w0.147: J15.14 22.24,4.07 22.03,4.28 22.03,4.71 22.02,4.72 22.02,5.65 21.06,6.61 C297.1 21.02,9.94 U62.3 21.02,11.4 20.37,12.05 20.37,12.36 20.69,12.69 24.38,12.69 v1(26.03,14.34)
HSEC_ADC1_AIN2: length 65.2
  TOP w0.147: U63.1 26.9,11.19 C298.1 26.9,9.45 v1(26.67,9.22) ; U1.T12 v1(62.58,34.43)
  L03_SIG1 w0.091: v1(26.67,9.22) 26.61,9.22 26.1,8.7 25.29,8.7 24.55,7.97 24.55,6.29 v1(23.84,5.58)
  L08_SIG2 w0.091: v1(26.67,9.22) 27.67,8.21 29.22,8.21 29.98,8.97 33.55,8.97 38.5,13.93 38.5,17.31 42.76,21.56 47.32,21.56 51.18,25.43 51.18,26.33 52,27.15 56.26,27.15 56.45,26.95 58.21,26.95 58.47,27.21 59.23,27.21 60.76,28.74 60.76,28.78 61.03,28.78 63.77,31.51 63.77,33.79 63.54,34.02 62.99,34.02 v1(62.58,34.43)
  BOTTOM w0.147: v1(23.84,5.58) 23.38,5.12 23.38,4.37 23.84,3.92 J15.18
HSEC_ADC1_AIN3: length 58.6
  TOP w0.147: U1.V12 v1(62.58,32.83) ; v1(23.84,7.61) 24.71,8.48 27.34,8.48 28.72,9.86 C299.1 28.76,9.94 U63.3 v1(28.76,12.18)
  L08_SIG2 w0.091: v1(28.76,12.18) 29.13,12.18 29.18,12.13 32.24,12.13 33.92,13.81 34.9,13.81 35.66,14.58 35.66,16.7 36.67,17.72 36.67,17.9 45.81,27.04 49.12,27.04 50.44,28.37 50.44,28.45 51.49,29.49 54.5,29.49 55.12,30.12 60.82,30.12 62.58,31.88 v1(62.58,32.83)
  BOTTOM w0.147: J15.20 24.64,5.71 23.84,6.51 v1(23.84,7.61)
HSEC_ADC1_AIN4: length 60.1
  TOP w0.147: U1.U12 v1(62.58,33.63)
  L03_SIG1 w0.091: v1(28.72,9) 27.83,9 26.44,7.61 v1(25.44,7.61)
  L08_SIG2 w0.091: v1(28.72,9) 29.54,9.83 32.61,9.83 36.48,13.7 36.48,16.22 37.59,17.33 37.59,17.78 45.9,26.1 49.21,26.1 51.36,28.25 51.36,28.33 51.66,28.63 56.71,28.63 56.88,28.8 59.54,28.8 60.36,29.61 60.83,29.61 62.97,31.75 62.97,33.24 v1(62.58,33.63)
  BOTTOM w0.147: U64.1 28.72,11.19 C302.1 v1(28.72,9) ; J15.24 26.24,5.15 24.98,6.4 24.98,7.15 v1(25.44,7.61)
HSEC_ADC1_AIN5: length 59.3
  TOP w0.147: U1.R12 v1(62.58,35.23)
  L08_SIG2 w0.091: v1(26.79,12.18) 26.79,12.55 31.55,17.31 34.05,17.31 34.84,18.1 34.84,20.35 42.42,27.93 42.92,27.93 44.06,29.07 46.03,29.07 47.22,30.26 49.26,30.26 49.99,30.98 53.9,30.98 54.53,31.62 58.97,31.62 60.07,32.71 60.07,34.06 60.84,34.84 62.19,34.84 v1(62.58,35.23)
  BOTTOM w0.147: v1(26.79,12.18) 26.79,11.42 26.86,11.35 U64.3 26.9,11.19 C303.1 26.9,9.86 27.23,9.52 27.23,8.84 26.24,7.85 26.24,6.19 27.49,4.93 27.49,4.37 27.04,3.92 J15.26
HSEC_ADC2_AIN0: length 35.4
  TOP w0.147: U1.R10 v1(60.98,35.23) ; U73.5 v1(49.17,18.78)
  L03_SIG1 w0.091: v1(60.98,35.23) 60.59,34.84 60.59,31.1 60.27,30.78 60.27,29.17 56.88,25.78 56.88,21.56 57.44,21.01 57.44,20.19 56.52,19.26 56.52,17.07 55.17,15.73 51.25,15.73 49.83,14.31 49.35,14.31 49.12,14.54 49.12,18.36 49.17,18.41 v1(49.17,18.78)
HSEC_ADC2_AIN0/ADC_R1_AIN0: length 42.9
  TOP w0.147: v1(28.64,6.59) 29.44,5.79 J15.31 ; C322.1 33.84,9.94 U69.3 v1(33.84,12.18) 34.16,12.5 37.57,12.5 45,19.93 47.22,19.93 47.87,19.27 U73.7
  L03_SIG1 w0.091: v1(28.64,6.59) 28.21,6.16 28.21,4.33 28.68,3.86 33.47,3.86 33.87,4.26 33.87,5.62 33.59,5.89 33.59,11.3 33.84,11.55 v1(33.84,12.18)
HSEC_ADC2_AIN1: length 11.1
  TOP w0.147: U1.T10 v1(60.98,34.43)
  L03_SIG1 w0.091: v1(60.98,34.43) 61.37,34.04 61.37,29.67 59.46,27.76 59.46,27.07 v1(58.67,26.28)
  BOTTOM w0.147: U70.2 59.06,25.94 58.71,26.28 v1(58.67,26.28)
HSEC_ADC2_AIN1/ADC_R1_AIN1: length 45.6
  TOP w0.147: 31.98,9.86 29.78,7.66 29.78,4.53 30.24,4.07 J15.33 ; 31.98,9.86 C321.1 31.94,9.94 U69.1 ; 31.98,9.86 32.6,9.23 35.38,9.23 35.68,9.53 35.68,10.61 36.43,11.35 45.15,11.35 46.53,12.73 46.53,15.07 v1(47.35,15.89)
  L08_SIG2 w0.091: v1(47.35,15.89) 47.57,15.67 50.18,15.67 v1(58.29,23.79)
  BOTTOM w0.147: U70.10 58.56,24.09 58.29,23.83 v1(58.29,23.79)
HSEC_ADC2_AIN2: length 61.3
  TOP w0.147: J15.37 31.84,4.1 31.42,4.51 31.42,4.52 31.38,4.56 31.38,4.56 31.24,4.71 31.24,7.99 31.77,8.52 31.81,8.52 32.17,8.88 35.87,8.88 36.23,8.52 38.86,8.52 v1(39.47,9.13) C304.1 ; U1.U10 v1(60.98,33.63)
  L08_SIG2 w0.091: v1(35.3,18.28) 35.3,20.29 41.51,26.51 43.56,26.51 45.66,28.61 48.18,28.61 50.19,30.62 54.05,30.62 54.68,31.25 59.34,31.25 60.56,32.47 60.56,33.21 v1(60.98,33.63)
  BOTTOM w0.147: v1(35.3,18.28) 35.3,17.43 36.41,16.32 36.41,12.97 37.33,12.04 38.4,12.04 39.05,11.4 U65.1 39.05,10.98 39.47,10.55 C304.1 v1(39.47,9.13)
HSEC_ADC2_AIN3: length 59.9
  TOP w0.147: v1(36.57,9.15) 36.46,9.26 C305.1 ; v1(31.87,5.45) 32.64,4.68 J15.39 ; U1.T9 v1(59.38,34.43)
  L08_SIG2 w0.091: v1(34.41,18.28) 34.41,26.35 37.23,29.17 40.69,29.17 41.31,29.8 45.96,29.8 46.88,30.71 49.2,30.71 49.84,31.35 53.75,31.35 54.38,31.98 58.82,31.98 59.77,32.93 59.77,34.04 v1(59.38,34.43) ; v1(31.87,5.45) 33.33,5.45 34.92,7.03 35.3,7.03 36.57,8.3 v1(36.57,9.15)
  BOTTOM w0.147: v1(34.41,18.28) 34.41,17.02 35.56,15.88 35.56,12.99 37.15,11.4 U65.3 36.46,10.55 C305.1 36.46,9.26 v1(36.57,9.15)
HSEC_ADC3_AIN0: length 19.1
  TOP w0.147: U1.U7 v1(57.78,33.63) ; U72.2 57,18.04 55.49,19.55 v1(55.29,19.55)
  L03_SIG1 w0.091: v1(57.78,33.63) 57.78,32.64 54.93,29.79 54.93,19.9 v1(55.29,19.55)
HSEC_ADC3_AIN0/ADC_R0_AIN2: length 61.1
  TOP w0.147: U69.4 C324.1 33.65,15.29 v1(33.65,15.86) 34.1,16.32 34.95,16.32 36.28,14.99 39.02,14.99 44.96,20.93 53.21,20.93 55.7,18.45 U72.4
  L03_SIG1 w0.091: v1(27.04,7.61) 27.84,6.81 27.84,4.2 28.51,3.53 33.74,3.53 34.06,3.85 34.06,5.7 33.77,5.99 33.77,9.2 35.3,10.73 35.3,16.01 34.67,16.65 34,16.65 33.65,16.3 v1(33.65,15.86)
  BOTTOM w0.147: J15.28 27.84,5.44 27.67,5.61 27.67,6.98 v1(27.04,7.61)
HSEC_ADC3_AIN1: length 21
  TOP w0.147: U1.U8 v1(58.58,33.63) ; U72.5 v1(55.05,16.21)
  L03_SIG1 w0.091: v1(58.58,33.63) 59.09,33.13 59.09,32.6 56.15,29.66 56.15,29.5 56.15,29.5 56.15,18.22 55.05,17.11 v1(55.05,16.21)
HSEC_ADC3_AIN1/ADC_R0_AIN3: length 46.1
  TOP w0.147: U72.7 53.75,19.91 53.02,20.63 45.17,20.63 37.42,12.88 32.53,12.88 31.94,13.47 U69.6 31.94,14.42 31.85,14.51 C323.1 31.85,15.25 v1(31.24,15.86)
  L03_SIG1 w0.091: v1(28.64,5.58) 29.18,6.12 29.18,12 29.18,12 29.18,12.36 29.18,12.36 29.18,14.38 30.66,15.86 v1(31.24,15.86)
  BOTTOM w0.147: J15.30 28.64,3.81 28.16,4.28 28.16,5.1 v1(28.64,5.58)
HSEC_ADC3_AIN2: length 36.6
  TOP w0.147: v1(54.52,12.94) 54.4,12.81 U72.11 ; U1.T7 v1(57.78,34.43)
  L03_SIG1 w0.091: v1(57.78,34.43) 57.78,34.18 57.39,33.79 57.39,32.84 54.47,29.91 54.47,26.47 53.18,25.19 52.52,25.19 46.68,19.35 46.68,12.99 47.23,12.44 54.02,12.44 v1(54.52,12.94)
HSEC_ADC3_AIN2/ADC_R1_AIN2: length 48.1
  TOP w0.147: v1(53.1,10.44) U72.9
  L03_SIG1 w0.091: v1(30.24,6.59) 30.24,6.96 30.16,7.04 30.16,14.23 31.37,15.44 31.57,15.44 v1(32,15.86)
  BOTTOM w0.147: J15.34 30.24,4.07 29.92,4.4 29.92,6.27 v1(30.24,6.59) ; U68.4 31.94,14.42 31.85,14.51 C320.1 32,15.25 v1(32,15.86) 32,17.97 33.05,19.02 41.23,19.02 42.82,17.44 47.42,17.44 49.16,15.69 51.48,15.69 53.3,13.87 53.3,13.42 52.67,12.79 52.67,10.87 v1(53.1,10.44)
HSEC_ADC3_AIN3: length 40.6
  TOP w0.147: v1(56.41,12.98) 56.42,12.98 56.35,12.91 U72.14 ; U1.R7 v1(57.78,35.23)
  L03_SIG1 w0.091: v1(57.78,35.23) 57.37,34.82 57.37,34.27 57.12,34.02 56.02,34.02 55.79,33.79 55.79,33.49 55.52,33.22 55.22,33.22 54.99,32.99 54.99,32.36 51.29,28.65 51.29,24.56 46.32,19.59 46.32,12.83 47.08,12.07 55.51,12.07 v1(56.41,12.98)
HSEC_ADC3_AIN3/ADC_R1_AIN3: length 46.5
  TOP w0.147: v1(52.74,13.55) 54.81,13.55 55.05,13.31 U72.12
  L03_SIG1 w0.091: v1(34.41,15.86) 33.31,14.77 33.31,7.18 32.02,5.88 v1(30.78,5.88)
  BOTTOM w0.147: J15.36 31.04,4.06 31.16,4.18 31.16,5.05 30.78,5.43 v1(30.78,5.88) ; U68.6 33.84,14.46 33.8,14.51 C319.1 33.8,15.25 v1(34.41,15.86) 33.68,16.6 33.68,18.18 34.22,18.73 39.78,18.73 41.49,17.02 47.23,17.02 48.96,15.3 50.99,15.3 v1(52.74,13.55)
HSEC_ADC3_AIN4: length 62.7
  TOP w0.147: U1.V8 v1(58.58,32.83)
  L03_SIG1 w0.091: v1(31.87,6.34) 31.32,6.89 31.32,9.83 31.89,10.4 31.89,14.34 32.88,15.34 32.88,16.23 32.1,17.01 29.6,17.01 v1(29.33,16.75)
  L08_SIG2 w0.091: v1(58.58,32.83) 58.19,33.22 53.2,33.22 52.9,32.92 49.94,32.92 48.58,31.56 41.75,31.56 40.3,30.11 36.71,30.11 29.33,22.74 v1(29.33,16.75)
  BOTTOM w0.147: U64.6 28.76,14.46 28.72,14.51 C300.1 28.72,15.14 29.33,15.76 v1(29.33,16.75) ; v1(31.87,6.34) 32.64,5.57 J15.40
HSEC_ADC3_AIN5: length 69.8
  TOP w0.147: U1.U9 v1(59.38,33.63)
  L03_SIG1 w0.091: v1(33.44,4.43) 32.61,4.43 32.45,4.27 31.65,4.27 30.36,5.56 30.36,6.06 30.73,6.44 30.73,9.89 31.43,10.59 31.43,14.53 32.43,15.53 32.43,16.04 32.15,16.32 27.38,16.32 v1(26.92,15.86)
  L08_SIG2 w0.091: v1(26.92,15.86) 27.35,15.44 28.75,15.44 30.81,17.5 30.81,23.53 36.86,29.58 40.46,29.58 41.07,30.2 42.68,30.2 43.65,31.17 48.84,31.17 49.38,31.72 53.6,31.72 54.23,32.35 58.65,32.35 59.38,33.08 v1(59.38,33.63)
  BOTTOM w0.147: U64.4 26.86,14.42 26.77,14.51 C301.1 26.77,15.72 v1(26.92,15.86) ; J15.42 v1(33.44,4.43)
