# Allegro board PROC159B.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
OSPI/QSPI_MUX_SEL: length 37.2
  TOP w0.147: v1(43.68,39.99) 43.64,40.04 R1679.1 ; U1.P16 v1(65.78,36.03)
  L08_SIG2 w0.091: v1(65.78,36.03) 66.17,36.42 66.72,36.42 66.97,36.67 66.97,37.79 66.72,38.04 60.82,38.04 60.03,38.83 60.03,39.13 59.37,39.79 55.87,39.79 54.99,40.67 54.99,41.79 55.24,42.04 55.54,42.04 55.77,42.27 55.77,43.39 55.54,43.62 52.82,43.62 49.51,40.31 44,40.31 v1(43.68,39.99)
  BOTTOM w0.147: U80.9 43.36,40.32 v1(43.68,39.99) ; U80.10 43.51,39.82 v1(43.68,39.99) ; v1(43.68,39.99) 44.14,39.99 R3836.1
OSPI_(W#): length 7.7
  TOP w0.147: R95.2 50.76,41.7 51.03,41.44 51.03,41.17 v1(51.07,41.13) 50.96,41.02 50.96,40.78 51.09,40.64 51.27,40.64 51.47,40.84 51.65,40.84 51.78,40.71 51.78,40.53 51.58,40.33 51.58,40.15 51.71,40.02 51.9,40.02 52.1,40.22 52.28,40.22 52.41,40.09 52.41,39.91 52.21,39.71 52.21,39.52 52.9,38.83 U1.L1
  BOTTOM w0.147: v1(51.07,41.13) 51.04,41.13 50.27,41.9 R3882.2
OSPI_CLK: length 25.1
  TOP w0.147: U19.B2 34.14,40.37 R110.1 36,40.06 v1(35.68,39.74)
  L03_SIG1 w0.091: v1(35.68,39.74) 35.68,36.38 36.17,35.89 36.85,35.89 36.93,35.97 36.93,36.32 37.01,36.4 37.13,36.4 37.21,36.32 37.21,35.97 37.29,35.89 37.4,35.89 37.48,35.97 37.48,36.32 37.56,36.4 37.68,36.4 37.76,36.32 37.76,35.97 37.84,35.89 39.05,35.89 39.14,35.98 39.14,36.78 39.79,37.43 39.79,37.85 39.79,37.85 39.79,41.64 39.79,41.64 39.79,42.43 39.79,42.43 39.79,43.94 41.35,45.5 41.46,45.5 v1(41.73,45.76)
  BOTTOM w0.147: U80.42 v1(41.73,45.76)
OSPI_CS0: length 19.2
  TOP w0.147: U19.C2 33.43,42.08 34.02,42.08 34.37,41.73 R109.2 36.1,41.23 v1(36.31,41.01) ; v1(46.1,37.38) TP45.1 48.05,36.83 48.92,36.83 R98.1
  L08_SIG2 w0.091: v1(36.31,41.01) 36.34,41.01 37.55,39.8 38.46,39.8 39.69,38.58 42.17,38.58 43.37,37.38 v1(46.1,37.38)
OSPI_DQ0: length 21.6
  TOP w0.147: R451.2 v1(32.6,49.39)
  L03_SIG1 w0.091: v1(32.6,49.39) 33,49.79 34.25,49.79 34.8,49.24 38.16,49.24 38.24,49.32 38.24,49.44 38.16,49.52 35.07,49.52 34.99,49.6 34.99,49.71 35.07,49.79 39.44,49.79 41.22,48 41.22,46.25 v1(40.73,45.76)
  BOTTOM w0.147: v1(32.6,49.39) 32.59,49.38 R100.1 ; U80.40 v1(40.73,45.76)
OSPI_DQ1: length 22.5
  TOP w0.147: v1(37.08,44.65) R452.2
  L03_SIG1 w0.091: v1(37.08,44.65) 36.47,44.65 35.53,45.59 35.53,48.53 35.68,48.68 36.36,48.68 36.51,48.53 36.51,45.98 36.43,45.9 36.31,45.9 36.14,46.07 36.14,48.35 36.06,48.43 35.95,48.43 35.87,48.35 35.87,45.86 36.49,45.23 38.25,45.23 38.5,45.49 v1(38.5,45.98)
  BOTTOM w0.147: v1(38.5,45.98) 38.5,44.03 38.71,43.82 U80.37 ; v1(37.08,44.65) 37.08,43.68 37.06,43.66 R101.1
OSPI_DQ2: length 23.4
  TOP w0.147: R453.2 v1(26.31,42.3) R102.2
  L03_SIG1 w0.091: v1(38.16,42.82) 37.43,42.09 33.98,42.09 33.9,42.01 33.9,41.9 33.98,41.82 36.72,41.82 36.8,41.74 36.8,41.62 36.72,41.54 33.13,41.54 30.58,44.09 28.09,44.09 v1(26.31,42.3)
  BOTTOM w0.147: U80.35 v1(38.16,42.82)
OSPI_DQ3: length 23
  TOP w0.147: R454.2 v1(26.31,44.84) R103.1
  L03_SIG1 w0.091: v1(38.16,41.82) 38.69,42.35 38.69,43.34 38.69,43.86 38.5,44.05 37.99,44.05 37.5,43.55 36.14,43.55 35.2,44.49 32.08,44.49 31.95,44.37 31.95,44.24 32.04,44.14 33.58,44.14 33.69,44.04 33.69,43.86 33.59,43.76 31.51,43.76 30.78,44.49 26.66,44.49 v1(26.31,44.84)
  BOTTOM w0.147: U80.33 v1(38.16,41.82)
OSPI_DQ4: length 24.7
  TOP w0.147: R455.2 v1(26.31,43.57) R104.1
  L03_SIG1 w0.091: v1(26.31,43.57) 25.88,43.14 25.88,42.12 26.13,41.87 27.04,41.87 28.86,43.69 30.45,43.69 33.57,40.57 35.59,40.57 35.67,40.65 35.67,40.76 35.58,40.85 33.68,40.85 33.59,40.94 33.59,41.05 33.67,41.13 35.7,41.13 35.88,40.95 35.88,40.79 36.26,40.41 36.82,40.41 37.91,39.32 v1(38.29,39.32)
  BOTTOM w0.147: U80.28 v1(38.29,39.32)
OSPI_DQ5: length 22.5
  TOP w0.147: R456.2 v1(30.48,48.63)
  L03_SIG1 w0.091: v1(30.48,48.63) 30.48,47.75 30.56,47.67 30.85,47.67 30.93,47.59 30.93,47.48 30.85,47.4 30.56,47.4 30.48,47.32 30.48,47.2 30.56,47.12 30.85,47.12 30.93,47.04 30.93,46.93 30.85,46.85 30.56,46.85 30.48,46.77 30.48,45.84 31.49,44.82 35.43,44.82 36.38,43.87 37.43,43.87 37.87,44.32 38.61,44.32 38.96,43.97 38.96,43.12 38.96,39 v1(38.29,38.32)
  BOTTOM w0.147: v1(30.48,48.63) 30.63,48.63 30.65,48.61 R105.1 ; U80.26 v1(38.29,38.32)
OSPI_DQ6: length 22.5
  TOP w0.147: v1(33.93,49.36) 33.85,49.28 R457.2
  L03_SIG1 w0.091: v1(38.29,37.32) 39.24,38.27 39.24,42.55 39.24,44.08 38.73,44.59 38.5,44.59 37.76,44.59 37.6,44.43 37.39,44.22 36.49,44.22 34.23,46.49 34.23,48.25 34.1,48.37 33.93,48.37 33.81,48.25 33.81,47.08 33.68,46.95 33.5,46.95 33.38,47.06 33.38,48.81 v1(33.93,49.36)
  BOTTOM w0.147: U80.24 v1(38.29,37.32) ; R106.1 33.99,49.25 33.93,49.31 v1(33.93,49.36)
OSPI_DQ7: length 23.3
  TOP w0.147: R458.2 v1(37.08,46.22)
  L03_SIG1 w0.091: v1(37.08,46.22) 37.08,46.59 37.06,46.6 37.06,48.41 37.15,48.5 37.28,48.5 37.39,48.4 37.39,46.8 37.6,46.59 37.75,46.59 37.83,46.67 37.83,48.45 37.91,48.53 38.03,48.53 38.11,48.45 38.11,46.68 38.2,46.59 38.73,46.59 39.79,45.52 39.79,44.72 39.51,44.44 39.51,37.55 v1(38.29,36.32)
  BOTTOM w0.147: R107.1 37.06,46.2 v1(37.08,46.22) ; U80.22 v1(38.29,36.32)
OSPI_DQS_SOC: length 18.4
  L03_SIG1 w0.091: v1(40.73,34.88) 34.23,34.88 29.85,39.25 29.85,42.75 v1(30.26,43.16)
  BOTTOM w0.147: U80.20 v1(40.73,34.88) ; R112.2 v1(30.26,43.16)
OSPI_ERR#: length 43.1
  TOP w0.147: v1(28.01,39.89) 27.75,39.89 27.49,40.15 R108.1 U19.A5 ; v1(48.52,46.32) 48.56,46.27 R3865.2
  L03_SIG1 w0.091: v1(48.52,46.32) 48.12,46.72 47.47,46.72 47.14,46.39 47.14,45.06 48.46,43.74 48.82,43.74 49.36,43.19 49.36,38.2 49.01,37.85 49.01,34.94 48.25,34.18 32.35,34.18 29.5,37.03 29.5,38.4 v1(28.01,39.89)
OSPI_LBCLK: length 22.2
  L03_SIG1 w0.091: v1(29.21,42.66) 28.82,42.27 28.82,39.62 33.99,34.45 41.3,34.45 v1(41.73,34.88)
  BOTTOM w0.147: U80.18 v1(41.73,34.88) ; R114.2 29.91,44.18 29.21,43.47 v1(29.21,42.66)
OSPI_RSTN: length 9.2
  TOP w0.147: U19.A4 30.85,39.31 30.98,39.18 v1(30.98,38.72)
  BOTTOM w0.147: U21.4 R121.1 35.68,38.2 35.16,38.72 v1(30.98,38.72)
OSPI_RSTN_R: length 3.5
  TOP w0.147: Q21.2 36.94,34.73 R3878.1 35.06,35.3 R3879.2
PMIC_COMP1_IN+: length 45.9
  TOP w0.147: J15.175 110.44,3.88 110.92,4.36 110.92,5.14 v1(110.49,5.58) ; U7.21 107.69,36.18 108.79,35.08 108.79,34.59 v1(109.12,34.27)
  L03_SIG1 w0.091: v1(110.49,5.58) 111.19,6.28 111.19,7.96 110.11,9.04 106.01,9.04 104.31,10.73 104.31,15.5 105.66,16.84 105.66,21.8 104.3,23.15 104.3,26.18 105.49,27.37 107.65,27.37 108.75,28.47 108.75,33.9 v1(109.12,34.27)
PMIC_COMP1_IN-: length 48.6
  TOP w0.147: v1(110.49,6.59) 111.24,5.84 J15.177 ; v1(110.89,34.34) 110.57,34.66 110.57,35.42 109.19,36.79 U7.24
  L03_SIG1 w0.091: v1(110.89,34.34) 110.41,34.82 109,34.82 108.51,34.33 108.51,28.71 107.53,27.73 105.45,27.73 103.86,26.14 103.86,23.07 105.47,21.46 105.47,18.31 104.02,16.86 104.02,10.66 106,8.68 110.09,8.68 110.93,7.84 110.93,7.04 v1(110.49,6.59)
PMIC_COMP2_IN+: length 56.7
  TOP w0.147: U7.28 107.69,46.57 v1(108.23,47.1) ; J15.171 v1(108.84,4.56)
  L03_SIG1 w0.091: v1(108.23,47.1) 105.76,44.64 104.3,44.64 102.93,43.26 102.93,38.71 101.14,36.92 101.14,27.38 101.59,26.94 101.59,19.79 102.32,19.06 102.32,9.41 104.73,7 104.73,4.86 105.46,4.13 108.41,4.13 v1(108.84,4.56)
PMIC_COMP2_IN-: length 55.7
  TOP w0.147: U7.25 109.19,45.99 v1(109.15,46.04) ; v1(110.49,7.61) 109.98,7.1 109.98,6.03 109.64,5.69 J15.173
  L03_SIG1 w0.091: v1(110.49,7.61) 109.74,8.36 105.97,8.36 103.75,10.58 103.75,17.27 104.5,18.02 104.5,21.88 103.53,22.85 103.53,26.74 101.81,28.46 101.81,34.08 102.86,35.13 102.86,36.59 104.51,38.24 106.4,38.24 106.99,38.83 106.99,43.89 v1(109.15,46.04)
PMIC_DIAG_OUT: length 78.9
  TOP w0.147: U7.32 v1(105.69,46.09) ; U1.V4 v1(55.38,32.83)
  L08_SIG2 w0.091: v1(105.69,46.09) 105.69,43.96 105.98,43.67 105.98,37.1 106.17,36.91 106.17,35.07 105.2,34.1 105.2,33.26 102.81,30.87 102.28,30.87 100.32,28.92 v1(100.32,25.79)
  BOTTOM w0.147: v1(100.32,25.79) 99.73,25.19 98.88,25.19 98.29,25.79 91.61,25.79 90.44,24.63 80.82,24.63 79.95,23.76 68.61,23.76 66.93,25.44 66.93,27.57 65.7,28.79 55.49,28.79 54.98,29.31 54.98,31.94 55.38,32.35 v1(55.38,32.83)
PMIC_EN_OUT: length 26.1
  TOP w0.147: U7.17 105.69,36.24 v1(105.74,36.19)
  L08_SIG2 w0.091: v1(97.62,48.91) 98.23,48.3 98.23,39.31 99.25,38.29 103.65,38.29 v1(105.74,36.19)
  BOTTOM w0.147: v1(97.62,48.91) 94.11,52.43 R51.1
PMIC_INTN: length 62.3
  TOP w0.147: U1.R17 v1(66.58,35.23) ; v1(109.92,34.3) 109.3,34.93 109.3,35.3 108.19,36.4 U7.22
  L03_SIG1 w0.091: v1(106.44,26.69) 107.35,26.69 109.03,28.37 109.03,33.4 v1(109.92,34.3)
  BOTTOM w0.114: v1(66.58,35.23) 66.18,34.83 66.18,33.36
  BOTTOM w0.147: v1(106.44,26.69) 106.35,26.61 91.21,26.61 90.86,26.25 68.22,26.25 67.49,26.99 67.49,28.63 66.18,29.93 66.18,33.36
PMIC_NRST: length 23.7
  TOP w0.147: R432.1 84.05,36.65 84.93,37.53 93.54,37.53 v1(94.37,38.36) ; v1(104.26,35.93) 103.94,36.25 103.94,36.25 103.69,36.5 U7.13
  L08_SIG2 w0.091: v1(94.37,38.36) 97.05,38.36 97.87,37.55 102.64,37.55 v1(104.26,35.93)
PMIC_SAFE_OUT1: length 109.2
  TOP w0.147: J15.113 65.44,5.79 v1(66.24,6.59)
  L08_SIG2 w0.091: v1(109.79,45.36) 109.79,37.11 108.44,35.76 108.44,33.09 105.8,30.46 105.8,27.59 104.06,25.85 104.06,24.58 104.53,24.11 104.53,18.12 103.91,17.49 103.91,15.74 104.28,15.36 104.28,11.53 104.76,11.05 107.19,11.05 108.22,10.02 108.22,9.51 109.64,8.09 109.64,4.25 108.92,3.53 105.93,3.53 104.4,5.06 95.61,5.06 94.5,6.17 94.5,8.88 90.99,12.39 90.99,12.91 90.56,13.34 70.33,13.34 69.11,12.12 69.11,8.86 66.84,6.59 v1(66.24,6.59)
  BOTTOM w0.147: R32.1 108.81,44.94 109.24,45.36 v1(109.79,45.36)
PMIC_SAFE_OUT2: length 80.4
  TOP w0.147: Q5.1 92.8,39.3 92.81,39.29 R202.1 94.07,39.96 95.78,41.67 95.78,46.58 97.24,48.04 97.67,48.04 98.51,48.88 v1(99.06,48.88) ; U7.27 v1(108.19,46.09)
  L03_SIG1 w0.091: v1(108.19,46.09) 106.36,44.26 104.94,44.26 103.89,43.21 103.89,38.8 101.44,36.35 101.44,28.37 103.06,26.75 103.06,21.1 102.8,20.84 102.8,18.97 102.56,18.73 102.56,9.46 105,7.03 105,6.44 105.36,6.08 109.05,6.08 109.76,5.37 109.76,5.11 v1(110.31,4.56)
  L08_SIG2 w0.091: v1(99.06,48.88) 101.53,48.88 102.25,48.16 106.77,48.16 107.62,47.31 107.62,46.66 v1(108.19,46.09)
  BOTTOM w0.147: v1(110.31,4.56) 110.63,4.24 110.86,4.24 111.24,3.86 J15.178
PMIC_SPI1_CLK: length 100.6
  TOP w0.147: U8.2 60.61,12.97 62.35,14.71 64.51,14.71 65.29,13.93 89.17,13.93 89.86,13.25 89.86,12.46 90.2,12.11 92.52,12.11 95.12,9.51 102.5,9.51 102.87,9.88 105.13,9.88 105.48,9.53 106.09,9.53 v1(106.62,10.06) ; U7.33 105.19,46.68 v1(104.77,47.1)
  L08_SIG2 w0.091: v1(104.77,47.1) 105.26,47.59 106.12,47.59 106.69,47.02 106.69,45.63 108.01,44.31 108.01,38.61 107.67,38.27 107.67,34.99 107.3,34.62 107.3,33.32 103.59,29.61 103.59,26.86 100.56,23.83 100.56,15.5 103.77,12.29 103.77,11.44 104.62,10.59 106.09,10.59 v1(106.62,10.06)
  BOTTOM w0.147: v1(104.77,47.1) 104.77,47.34 R41.2
PMIC_SPI1_CS0: length 97
  TOP w0.147: v1(103.75,46.08) 103.69,46.03 U7.36 ; U8.14 61.26,16.06 62.1,15.23 64.64,15.23 65.63,14.24 89.33,14.24 90.16,13.4 91.79,13.4 95.32,9.87 102.3,9.87 102.8,10.38 105.39,10.38 v1(105.71,10.06)
  L08_SIG2 w0.091: v1(105.71,10.06) 105.45,10.32 104.48,10.32 103.5,11.3 103.5,12.18 100.38,15.3 100.38,24.29 102.14,26.05 102.14,29.18 102.8,29.84 103.4,29.84 106.18,32.62 106.18,34.21 107.36,35.39 107.36,38.22 107,38.58 107,44.22 106.27,44.95 106.27,46.17 105.87,46.58 104.24,46.58 v1(103.75,46.08)
  BOTTOM w0.147: v1(103.75,46.08) 103.3,46.08 102.99,46.39 R39.2
PMIC_SPI1_D0: length 113.4
  TOP w0.147: R40.2 109.11,54.22 109.08,54.19 TP17.1 v1(107.72,54.19) ; v1(107.54,10.06) 106.6,9.12 105.29,9.12 104.88,9.52 103.1,9.52 102.71,9.13 94.99,9.13 92.37,11.75 90.02,11.75 89.5,12.28 89.5,13.1 88.97,13.63 65,13.63 64.38,14.24 63.27,14.24 62.56,13.53 U8.5 ; v1(103.75,47.1) 104.22,46.64 104.22,45.94 104.19,45.92 U7.35
  L03_SIG1 w0.091: v1(107.72,54.19) 107.72,52.31 104.52,49.1 104.52,47.87 v1(103.75,47.1)
  L08_SIG2 w0.091: v1(107.54,10.06) 106.76,10.83 104.63,10.83 104.05,11.42 104.05,12.39 100.74,15.69 100.74,23.57 104.76,27.59 104.76,30.41 107.21,32.86 107.75,32.86 108.23,33.34 108.23,36.99 109.4,38.16 109.4,43.9 107.07,46.23 107.07,47.17 106.37,47.87 104.52,47.87 v1(103.75,47.1)
PMIC_SPI1_D1: length 81.8
  TOP w0.147: U8.11 63.21,19.31 63.37,19.47 v1(63.37,19.93)
  L08_SIG2 w0.091: v1(104.86,25.88) 106.16,27.19 106.16,30.18 108.69,32.71 108.69,34.87 110.91,37.09 110.91,51.11 109.35,52.67 v1(109.35,55.35)
  BOTTOM w0.147: v1(109.35,55.35) R38.2 R142.2 ; v1(63.37,19.93) 64.38,20.94 65.55,20.94 68.04,23.43 80.21,23.43 80.97,24.19 90.62,24.19 91.75,25.32 98.03,25.32 98.59,24.76 100.14,24.76 101.26,25.88 v1(104.86,25.88)
PMIC_WKUP1: length 66.9
  TOP w0.147: v1(100.22,36.06) 100.19,36.08 U7.6
  L03_SIG1 w0.091: v1(74.81,25.76) 75.93,24.63 75.93,18.28 71.94,14.29 70.75,14.29 66.95,10.49 66.95,9.54 66.24,8.83 v1(66.24,7.61)
  L08_SIG2 w0.091: v1(99.31,25.79) 99.83,26.31 99.83,35.67 v1(100.22,36.06)
  BOTTOM w0.147: v1(74.81,25.76) 75.26,25.76 75.4,25.62 R34.2 78.08,24.91 79.04,25.87 91.16,25.87 91.52,26.23 98.86,26.23 v1(99.31,25.79) ; v1(66.24,7.61) 65.44,6.81 J15.114
PMIC_WKUP2: length 103.7
  TOP w0.147: v1(108.84,5.58) 109.39,6.13 109.39,7.89 108.03,9.26 108.03,10.23 107.4,10.86 94.87,10.86 91.98,13.75 90.27,13.75 89.43,14.59 75.28,14.59 74.14,15.73 J22.1 ; U7.43 100.19,45.97 100.06,46.1 100.06,46.64 99.2,47.5 99.04,47.5 v1(98.67,47.87)
  L03_SIG1 w0.091: v1(108.84,5.58) 109.26,5.15 109.26,4.38 108.83,3.95 105.38,3.95 104.55,4.79 104.55,6.93 102.13,9.34 102.13,18.88 101.34,19.68 101.34,26.74 100.73,27.35 100.73,36.65 99.9,37.48 99.9,46.64 v1(98.67,47.87)
  BOTTOM w0.147: J15.172 108.84,3.92 108.38,4.37 108.38,5.12 v1(108.84,5.58)
PORZ: length 261.1
  TOP w0.147: v1(86.22,36.38) 87.14,35.46 TP75.1 87.14,34.07 86.61,33.54 86.61,32.36 86.13,31.88 86.13,29.48 85.64,28.99 U79.4 84.57,28.99 83.13,27.55 82.29,27.55 v1(82.01,27.27) 81.1,26.35 69.65,26.35 66.13,22.83 62.05,22.83 61.25,22.02 50.98,22.02 47.59,25.41 41.27,25.41 40.43,26.25 39.32,26.25 38.37,27.2 38.37,31.31 v1(38.3,31.38) 38.17,31.51 Q21.1 36.7,31.51 36.09,30.9 34.23,30.9 33.57,31.56 33.57,33.39 33.19,33.77 29.15,33.77 28.47,33.08 24.2,33.08 21.91,35.37 21.91,52.66 25.77,56.51 25.77,60.89 27.7,62.82 27.7,63.65 26.9,64.45 26.9,66.67 28.66,68.43 41.14,68.43 45.95,73.24 45.95,74.38 46.62,75.05 46.62,77.77 45.75,78.64 45.75,85.2 48.86,88.3 52.22,88.3 54.35,90.44 57.45,90.44 v1(58.21,91.2) 59.11,90.3 61.94,90.3 63.55,91.91 67.18,91.91 67.54,92.26 67.54,99.86 v1(68,100.32) ; U1.R2 v1(53.78,35.23) ; R419.1 67.93,11.93 v1(67.81,12.05) ; U36.2 v1(80.76,39.79)
  L08_SIG2 w0.091: v1(38.3,31.38) 38.3,32.42 39.21,33.34 48.54,33.34 49.9,34.7 52.64,34.7 53.17,35.23 v1(53.78,35.23) ; v1(67.81,12.05) 69.76,14 78.42,14 80.79,16.37 80.79,23.68 82.09,24.98 82.09,27.19 v1(82.01,27.27)
  BOTTOM w0.147: U21.2 32.67,36.27 33.09,35.85 33.09,34.86 33.57,34.38 35.3,34.38 v1(38.3,31.38) ; v1(58.21,91.2) 58.18,91.23 R327.1 ; v1(53.78,35.23) 53.4,34.85 53.4,34.72 52.92,34.25 R187.1 ; v1(86.22,36.38) 82.11,36.38 81.21,35.48 80.59,35.48 80.05,36.01 80.05,39.08 v1(80.76,39.79) ; v1(68,100.32) U39.2
PORZ_RST: length 158.9
  TOP w0.147: U78.3 v1(80.19,32.03)
  L03_SIG1 w0.091: v1(104.95,97.59) 104.95,103.58 100.4,108.12 81.23,108.12 75.29,102.18 71.4,102.18 70.47,103.11 67.89,103.11 67.17,102.39 57.06,102.39 v1(52.9,98.23)
  L08_SIG2 w0.091: v1(96.61,48.91) 95.56,49.96 95.56,65.63 94.82,66.37 94.82,72.52 90.72,76.63 90.72,77.55 90.99,77.82 91.94,77.82 92.27,77.49 99.94,77.49 105.78,83.33 105.78,96.75 v1(104.95,97.59)
  BOTTOM w0.147: U76.7 53.06,95.46 52.9,95.62 R427.2 v1(52.9,98.23) ; v1(80.19,32.03) 81.11,32.03 82.03,32.95 82.03,34.79 83.08,35.84 86.44,35.84 86.81,36.2 86.81,39.11 v1(96.61,48.91)
PORZ_VMAIN: length 1.8
  TOP w0.147: U78.4 U79.1
PR0_IEP0_EDC_SYNC_OUT0: length 2
  TOP w0.147: R420.1 J16.1
PR0_IEP0_EDC_SYNC_OUT1: length 10.4
  TOP w0.147: R422.1 63.82,53.34 64.28,53.79 64.28,54.88 J18.1
PR0_IEP0_EDIO_DATA_IN_OUT30: length 12.5
  BOTTOM w0.147: R421.1 63.68,54.92 62.08,56.52 62.08,62.22 63.81,63.95 J17.1
PR0_IEP0_EDIO_DATA_IN_OUT31: length 2.4
  TOP w0.147: J19.1 67.96,18.09 68.45,17.61 R423.1
PR0_MDIO0_MDC: length 21.2
  TOP w0.147: R470.2 v1(77.35,29.38) ; R211.2 73.96,37.22 v1(74.47,36.71)
  L03_SIG1 w0.091: v1(74.47,36.71) 73.86,37.31 73.86,37.81 74.25,38.2 74.72,38.2 76.64,36.27 76.64,30.09 v1(77.35,29.38)
  BOTTOM w0.147: U90.2 77.9,37.43 77.5,37.83 75.59,37.83 v1(74.47,36.71) ; R470.2 v1(77.35,29.38)
PR0_MDIO0_MDC_ADD: length 87.7
  TOP w0.147: J8.20 71.79,91.44 v1(71.53,91.19)
  L08_SIG2 w0.091: v1(68.28,79.8) 67.43,80.65 67.43,83.4 68.38,84.34 69.93,84.34 70.3,84.71 70.3,85.25 71.53,86.48 v1(71.53,91.19)
  BOTTOM w0.147: U90.4 76.9,35.09 76.77,34.96 R3867.2 75.37,34.4 75.1,34.12 74.23,34.12 73.39,34.96 73.39,38.82 75.75,41.18 75.75,44.7 76.59,45.55 76.59,46.64 76.07,47.16 74.85,47.16 74.39,47.62 72.29,47.62 71.96,47.95 71.78,48.12 71.78,49.53 72.03,49.78 72.03,51.52 71.09,52.45 68.02,52.45 63.32,57.15 63.32,62.14 65.35,64.17 65.35,66.58 64.98,66.95 61.6,66.95 60.9,67.65 60.9,70.46 62.45,72.01 62.45,78.75 63.8,80.11 64.64,80.11 65.42,79.32 67.81,79.32 v1(68.28,79.8)
PR0_MDIO0_MDC_ON: length 62.6
  L08_SIG2 w0.091: v1(86.22,35.29) 90.53,39.6 90.53,47.64 92.47,49.58 92.47,57.71 93.06,58.3 93.06,62.31 91.35,64.02 91.35,73.72 89.92,75.15 v1(89.53,75.15)
  BOTTOM w0.147: U81.4 76.96,28.38 77.52,28.94 R472.2 82.52,28.94 84.3,30.72 84.3,34.02 84.86,34.58 85.52,34.58 v1(86.22,35.29) ; U35.42 88.92,73.64 89.53,74.25 v1(89.53,75.15)
PR0_MDIO0_MDIO: length 20.9
  TOP w0.147: R471.2 71.74,28.48 71.34,28.88 v1(70.68,28.88) ; R208.2 v1(74.47,34.7)
  L03_SIG1 w0.091: v1(74.47,34.7) 74.91,34.26 74.91,32.68 73.51,31.28 72.69,31.28 70.68,29.27 v1(70.68,28.88)
  BOTTOM w0.147: U90.8 77.4,38.96 76.84,38.4 74.45,38.4 73.81,37.76 73.81,35.36 v1(74.47,34.7) ; U81.8 v1(70.68,28.88)
PR0_MDIO0_MDIO_ADD: length 78.2
  TOP w0.147: J8.22 v1(73.27,91.84)
  L08_SIG2 w0.091: v1(68.28,78.89) 68.73,79.34 68.73,79.99 67.63,81.09 67.63,83.32 68.33,84.02 70.9,84.02 71.96,85.08 71.96,90.53 v1(73.27,91.84)
  BOTTOM w0.147: v1(68.28,78.89) 65.3,78.89 64.51,79.68 63.79,79.68 62.74,78.63 62.74,71.89 61.2,70.34 61.2,67.77 61.72,67.25 65.1,67.25 65.65,66.7 65.65,64.05 63.61,62.02 63.61,57.27 68.14,52.75 71.21,52.75 72.32,51.64 72.32,49.59 72.2,49.47 72.2,48.12 72.41,47.91 74.52,47.91 74.98,47.45 76.19,47.45 77.19,46.46 77.19,42.26 76.99,42.07 R3866.2 U90.6
PR0_MDIO0_MDIO_ON: length 72.1
  L08_SIG2 w0.091: v1(88.36,73.01) 89.63,74.28 90.16,74.28 90.93,73.5 90.93,65.79 90.31,65.16 90.31,63.69 92.81,61.19 92.81,58.4 92.22,57.81 92.22,49.68 90.29,47.75 90.29,41.43 85.78,36.92 85.78,34.77 v1(86.22,34.32)
  BOTTOM w0.147: U35.41 88.42,72.95 v1(88.36,73.01) ; v1(86.22,34.32) 85.39,33.49 85.39,31.28 81.9,27.79 78.84,27.79 78.3,28.33 77.72,28.33 77.52,28.13 77.52,27.65 77.67,27.5 77.67,27.06 77.33,26.72 70.33,26.72 70.15,26.9 R473.2 70.55,27.88 U81.6
PR0_PRU0_GPIO0: length 35.3
  TOP w0.147: U87.2 v1(79.01,56.89) ; U1.K17 v1(66.58,39.23)
  L03_SIG1 w0.091: v1(66.58,39.23) 67.03,38.78 69.26,38.78 69.63,39.16 72.65,39.16 73.18,39.69 73.83,39.69 79.68,45.54 79.68,50.46 80.93,51.71 80.93,58.12 80.67,58.38 80.37,58.38 80.22,58.24 80.22,57.69 80.12,57.59 79.83,57.59 79.72,57.7 79.72,58.25 79.59,58.38 79.17,58.38 79.01,58.23 v1(79.01,56.89)
PR0_PRU0_GPIO1: length 35.2
  TOP w0.147: v1(79.74,56.45) 79.74,56.86 79.2,57.39 U87.3 ; U1.K18 v1(67.38,39.23)
  L03_SIG1 w0.091: v1(79.74,56.45) 80.58,55.61 80.58,51.75 79.41,50.57 79.41,45.88 78.75,45.22 78.6,45.22 78.31,45.51 78.16,45.51 78.05,45.4 78.05,45.25 78.34,44.96 78.34,44.81 78.23,44.71 78.08,44.71 77.79,44.99 77.64,44.99 77.54,44.88 77.54,44.73 77.82,44.45 77.82,44.29 77.71,44.19 77.56,44.19 77.28,44.47 77.12,44.47 77.02,44.36 77.02,44.21 77.3,43.93 77.3,43.78 76.46,42.93 76.31,42.93 76.13,43.11 75.98,43.11 75.88,43 75.88,42.85 76.05,42.68 76.05,42.52 75.94,42.42 75.79,42.42 75.62,42.59 75.46,42.59 75.36,42.48 75.36,42.33 75.53,42.16 75.53,42.01 75.42,41.9 75.27,41.9 75.1,42.07 74.95,42.07 74.84,41.97 74.84,41.81 75.01,41.64 75.01,41.49 74.91,41.38 74.75,41.38 74.58,41.56 74.43,41.56 74.32,41.45 74.32,41.3 74.5,41.12 74.5,40.97 74.39,40.87 74.24,40.87 74.06,41.04 73.91,41.04 73.81,40.93 73.81,40.78 73.98,40.61 73.98,40.45 73.71,40.18 70.12,40.18 69.17,39.23 v1(67.38,39.23)
PR0_PRU0_GPIO2: length 35.3
  TOP w0.147: U1.J18 v1(67.38,40.83) ; v1(79.27,54.97) 80.19,55.9 80.19,57 79.3,57.89 U87.4
  L03_SIG1 w0.091: v1(67.38,40.83) 68.87,40.83 73.86,45.82 74.45,45.82 75.21,46.57 75.21,46.73 74.93,47 74.93,47.15 75.04,47.26 75.19,47.26 75.47,46.98 75.62,46.98 76.47,47.84 76.47,50.85 76.71,51.09 77,51.09 77.2,50.89 77.2,49.02 77.44,48.78 78.02,48.78 78.53,49.29 78.53,52.03 78.19,52.37 77.43,52.37 77.33,52.48 77.33,52.63 77.44,52.74 78.19,52.74 78.3,52.84 78.3,53 78.19,53.1 77.43,53.1 77.33,53.21 77.33,53.36 77.44,53.47 78.19,53.47 78.3,53.58 78.3,54.01 v1(79.27,54.97)
PR0_PRU0_GPIO3: length 35.1
  TOP w0.147: U87.5 79.69,58.39 80.52,57.56 80.52,55.57 79.4,54.46 78.79,54.46 v1(78.14,55.11) ; U1.J17 v1(66.58,40.83)
  L03_SIG1 w0.091: v1(66.58,40.83) 66.81,40.83 67.2,41.22 67.52,41.22 69.94,43.63 70.4,43.63 73.03,46.26 74.11,46.26 74.58,46.73 74.58,47.84 74.86,48.13 74.86,48.28 74.48,48.66 74.48,48.81 74.58,48.92 74.74,48.92 75.12,48.54 75.27,48.54 75.38,48.64 75.38,48.79 74.99,49.18 74.99,49.33 75.1,49.44 75.25,49.44 75.63,49.05 75.79,49.05 76.09,49.36 76.09,49.9 75.99,50.01 75.58,50.01 75.47,50.12 75.47,50.27 75.58,50.38 75.99,50.38 76.09,50.48 76.09,51.47 75.99,51.58 75.42,51.58 75.31,51.68 75.31,51.84 75.42,51.94 75.99,51.94 76.09,52.05 76.09,52.2 75.99,52.31 75.42,52.31 75.31,52.42 75.31,52.57 75.42,52.67 75.99,52.67 76.09,52.78 76.09,53.6 77.6,55.11 v1(78.14,55.11)
PR0_PRU0_GPIO4: length 35.2
  TOP w0.147: U87.6 v1(79.01,58.89) ; U1.K16 v1(65.78,39.23)
  L03_SIG1 w0.091: v1(65.78,39.23) 66.28,39.73 67.76,39.73 68.19,40.16 69.28,40.16 72.84,43.72 75.03,43.72 75.33,44.02 75.33,44.17 75.17,44.33 75.17,44.48 75.28,44.59 75.43,44.59 75.59,44.43 75.74,44.43 75.85,44.54 75.85,44.69 75.69,44.84 75.69,45 75.8,45.1 75.95,45.1 76.1,44.95 76.26,44.95 76.36,45.06 76.36,45.21 76.21,45.36 76.21,45.51 76.32,45.62 76.47,45.62 76.62,45.47 76.77,45.47 76.88,45.57 76.88,45.72 76.73,45.88 76.73,46.03 76.83,46.14 76.99,46.14 77.14,45.98 77.29,45.98 77.4,46.09 77.4,46.24 77.24,46.4 77.24,46.55 77.35,46.65 77.5,46.65 77.66,46.5 77.81,46.5 77.92,46.61 77.92,46.76 77.76,46.91 77.76,47.06 77.87,47.17 78.02,47.17 78.17,47.02 78.33,47.02 78.43,47.12 78.43,47.28 78.28,47.43 78.28,47.58 78.39,47.69 78.54,47.69 78.69,47.53 78.84,47.53 79.13,47.82 79.13,50.69 80.31,51.87 80.31,55.26 79.15,56.41 78.84,56.41 78.57,56.68 78.57,58.45 v1(79.01,58.89)
PR0_PRU0_GPIO5: length 35.6
  TOP w0.147: U87.7 79.43,59.39 v1(79.93,58.89) ; U1.G17 v1(66.58,42.43)
  L03_SIG1 w0.091: v1(79.93,58.89) 80.57,59.54 80.57,61.17 80.36,61.38 80.36,62.14 80.12,62.38 79.8,62.38 79.44,62.74 79.44,63.16 79.22,63.38 78.81,63.38 78.45,63.02 78.45,62.78 77.83,62.15 77.83,60.19 77.4,59.76 75.49,59.76 75.21,59.48 75.21,54.52 73.48,52.79 73.48,50.83 71.4,48.75 71.4,47.25 v1(66.58,42.43)
PR0_PRU0_GPIO6: length 35.5
  TOP w0.147: U87.11 79.43,61.39 v1(79.93,61.89) ; U1.K15 v1(64.98,39.23)
  L03_SIG1 w0.091: v1(64.98,39.23) 65.75,40 67.64,40 68.08,40.44 69.1,40.44 72.65,43.99 74,43.99 78.86,48.85 78.86,50.8 79.74,51.68 79.74,55.17 79.47,55.44 78.8,55.44 78.3,55.94 78.3,58.8 78.85,59.35 78.85,59.8 79.46,60.4 79.46,61.42 v1(79.93,61.89)
PR0_PRU0_GPIO8: length 35.1
  TOP w0.147: U1.G15 v1(64.98,42.43) ; U87.12 v1(79.01,61.89)
  L03_SIG1 w0.091: v1(64.98,42.43) 65.38,42.83 65.96,42.83 66.19,42.59 66.19,42.25 66.42,42.02 67.57,42.02 69.77,44.21 70.49,44.21 71.04,44.76 71.04,44.92 70.66,45.3 70.66,45.45 70.77,45.56 70.92,45.56 71.3,45.17 71.45,45.17 71.56,45.28 71.56,45.43 71.18,45.82 71.18,45.97 71.28,46.08 71.43,46.08 71.82,45.69 71.97,45.69 72.08,45.8 72.08,45.95 71.69,46.34 71.69,46.49 71.8,46.6 71.95,46.6 72.34,46.21 72.49,46.21 72.6,46.32 72.6,46.47 72.21,46.85 72.21,47.01 72.32,47.11 72.47,47.11 72.86,46.73 73.01,46.73 73.7,47.42 73.7,47.86 73.32,48.23 73.32,49.19 74.89,50.76 74.89,52.81 78.02,55.94 78.02,58.99 78.51,59.47 78.51,61.39 v1(79.01,61.89)
PR0_PRU0_GPIO9: length 30.9
  TOP w0.147: U1.F17 v1(66.58,43.23) ; U87.13 79.43,62.39 v1(79.93,62.89)
  L03_SIG1 w0.091: v1(66.58,43.23) 68.78,45.43 68.78,47.81 72.1,51.13 72.1,52.01 74.93,54.84 74.93,61.64 75.41,62.11 77.36,62.11 78.03,62.78 78.03,62.99 78.7,63.66 79.54,63.66 79.93,63.27 v1(79.93,62.89)
PR0_PRU0_GPIO10: length 26.7
  TOP w0.147: U87.14 v1(79.01,62.89) ; U1.G18 v1(67.38,42.43)
  L03_SIG1 w0.091: v1(79.01,62.89) 78.17,62.05 78.17,59.92 77.75,59.51 77.75,56.33 73.93,52.51 73.93,50.7 71.75,48.52 71.75,47.17 67.38,42.8 v1(67.38,42.43)
PR0_PRU0_GPIO11: length 79.9
  TOP w0.147: U1.M16 v1(65.78,37.63)
  L03_SIG1 w0.091: v1(80.39,99.84) 79.96,99.84 77.32,97.19 77.32,80.14 73.1,75.92 73.1,74.03 69.23,70.16 66.4,70.16 62.4,66.16 62.4,63.28 61.63,62.51 61.63,53.64 60.86,52.87 60.86,47.29 60.58,47.01 60.58,40.46 61.35,39.69 62.76,39.69 62.97,39.48 62.97,37.42 63.16,37.23 65.38,37.23 v1(65.78,37.63)
  BOTTOM w0.147: v1(80.39,99.84) 80.89,99.34 U88.4
PR0_PRU0_GPIO12: length 79.7
  TOP w0.147: U1.M15 v1(64.98,37.63)
  L03_SIG1 w0.091: v1(64.98,37.63) 64.58,38.03 64.03,38.03 63.79,38.27 63.79,39.43 63.31,39.92 62.08,39.92 61.38,40.62 61.38,48.94 62.74,50.3 62.74,50.45 62.54,50.65 62.54,50.8 62.65,50.91 62.8,50.91 63,50.71 63.15,50.71 63.26,50.82 63.26,50.97 63.06,51.17 63.06,51.32 63.17,51.43 63.32,51.43 63.52,51.23 63.67,51.23 64.02,51.58 64.02,52.4 61.91,54.52 61.91,62.4 62.67,63.16 62.67,66.05 66.51,69.88 69.28,69.88 73.37,73.97 73.37,75.84 77.59,80.06 77.59,96.84 80.09,99.34 80.81,99.34 v1(81.3,99.84)
  BOTTOM w0.147: U88.5 v1(81.3,99.84)
PR0_PRU0_GPIO13: length 80
  TOP w0.147: U1.H17 v1(66.58,41.63)
  L03_SIG1 w0.091: v1(80.39,100.84) 80.88,100.34 81.48,100.34 81.94,99.89 81.94,97.78 81.34,97.19 80.65,97.19 80.04,96.58 80.04,94.68 78.69,93.33 78.69,77.31 78.57,77.18 77.19,77.18 76.62,76.62 75.35,76.62 74.1,75.37 74.1,73.61 65.46,64.97 65.46,64.21 62.71,61.46 62.71,56.21 66.89,52.04 66.89,48.75 66.4,48.27 64.41,48.27 63.78,47.64 63.78,41.48 64.02,41.24 66.02,41.24 66.41,41.63 v1(66.58,41.63)
  BOTTOM w0.147: v1(80.39,100.84) 80.89,100.34 U88.6
PR0_PRU0_GPIO14: length 80.3
  TOP w0.147: U1.H16 v1(65.78,41.63)
  L03_SIG1 w0.091: v1(65.78,41.63) 65.39,42.02 64.84,42.02 64.59,42.27 64.59,47.57 64.93,47.9 65.96,47.9 66.28,47.58 66.28,45.68 66.43,45.53 66.64,45.53 66.78,45.67 66.78,47.48 67.18,47.87 67.18,52.16 63,56.33 63,61.36 65.74,64.1 65.74,64.86 74.31,73.43 74.31,75.13 75.39,76.21 78.53,76.21 78.92,76.61 78.92,93.11 80.34,94.53 80.34,96.18 81.03,96.87 81.41,96.87 82.21,97.67 82.21,100.3 81.67,100.84 v1(81.3,100.84)
  BOTTOM w0.147: U88.7 v1(81.3,100.84)
PR0_PRU0_GPIO15: length 79.9
  TOP w0.147: U1.L16 v1(65.78,38.43)
  L03_SIG1 w0.091: v1(80.39,98.84) 79.26,97.71 79.26,94.89 78.15,93.78 78.15,80.2 73.61,75.66 73.61,73.88 64.93,65.19 64.93,64.43 62.18,61.68 62.18,54.63 64.58,52.23 64.58,50.54 64.42,50.38 64.26,50.38 63.91,50.73 63.76,50.73 63.65,50.63 63.65,50.48 64.01,50.12 64.01,49.97 63.9,49.86 63.75,49.86 63.39,50.22 63.24,50.22 63.13,50.11 63.13,49.96 63.49,49.6 63.49,49.45 63.38,49.34 63.23,49.34 62.87,49.7 62.72,49.7 62.61,49.59 62.61,49.44 62.97,49.08 62.97,48.93 62.86,48.83 62.71,48.83 62.36,49.18 62.2,49.18 62.1,49.08 62.1,48.92 62.45,48.57 62.45,48.42 62.18,48.14 62.18,40.6 62.57,40.21 64.05,40.21 64.59,39.67 64.59,39.02 64.79,38.82 65.39,38.82 v1(65.78,38.43)
  BOTTOM w0.147: v1(80.39,98.84) 80.89,98.34 U88.2
PR0_PRU0_GPIO16: length 79.7
  TOP w0.147: U1.H18 v1(67.38,41.63)
  L03_SIG1 w0.091: v1(67.38,41.63) 67.17,41.42 66.98,41.42 66.8,41.24 66.37,41.24 66.18,41.06 66.18,40.61 65.98,40.41 63.2,40.41 62.98,40.63 62.98,47.5 63.21,47.73 63.21,47.88 62.96,48.12 62.96,48.27 63.07,48.38 63.22,48.38 63.47,48.14 63.62,48.14 63.72,48.24 63.72,48.39 63.48,48.64 63.48,48.79 63.59,48.9 63.74,48.9 63.98,48.65 64.13,48.65 64.24,48.76 64.24,48.91 64,49.16 64,49.31 64.11,49.41 64.26,49.41 64.5,49.17 64.65,49.17 64.76,49.28 64.76,49.43 64.52,49.67 64.52,49.82 64.62,49.93 64.77,49.93 65.02,49.69 65.17,49.69 65.28,49.79 65.28,49.95 65.03,50.19 65.03,50.34 65.14,50.45 65.29,50.45 65.53,50.2 65.69,50.2 65.93,50.45 65.93,52.54 62.44,56.03 62.44,61.57 65.19,64.32 65.19,65.09 73.87,73.77 73.87,75.55 78.43,80.1 78.43,93.59 79.62,94.78 79.62,97.16 v1(81.3,98.84)
  BOTTOM w0.147: U88.3 v1(81.3,98.84)
PR0_PRU0_REF_CLK: length 118.9
  TOP w0.147: R272.2 16.23,33.65 16.39,33.49 v1(18.79,33.49)
  L03_SIG1 w0.091: v1(18.79,33.49) 18.79,58.87 25.08,65.17 41.01,65.17 v1(43.31,62.87)
  L08_SIG2 w0.091: v1(88.42,64.25) 91.05,61.62 91.05,60.74 86.19,55.87 82.85,55.87 81.34,54.36 71.8,54.36 70.38,55.78 69.29,55.78 68.96,56.11 67.42,56.11 66.63,56.9 66.63,58.11 66.37,58.37 66.02,58.37 65.53,58.87 65.11,58.87 63.61,57.37 54.97,57.37 53.46,58.88 53.46,59.89 50.11,63.24 49.45,63.24 49.08,62.87 v1(43.31,62.87)
  BOTTOM w0.147: U35.20 v1(88.42,64.25)
PR0_PRU1_GPIO0: length 57.5
  BOTTOM w0.147: U89.2 81.67,85.35 81.41,85.08 81.41,84.68 81.99,84.1 81.99,80.65 82.67,79.96 82.67,71.47 81.46,70.25 81.46,65.9 85.82,61.54 85.82,56.17 80.62,50.97 80.62,46.98 81.3,46.3 81.71,46.3 82.19,45.83 82.19,44.98 81.62,44.4 78.59,44.4 78.24,44.76 78.24,49.96 77.93,50.27 R247.2
PR0_PRU1_GPIO1: length 57
  TOP w0.147: R248.2 77.52,50.27 v1(78.04,50.79)
  BOTTOM w0.147: v1(78.04,50.79) 78.67,50.16 78.67,45.09 78.94,44.83 80.92,44.83 81.28,45.19 81.28,45.63 80.33,46.59 80.33,51.27 85.27,56.22 85.27,61.63 81.13,65.77 81.13,70.39 82.35,71.61 82.35,79.83 81.67,80.5 81.67,83.99 81.02,84.65 81.02,85.41 81.46,85.85 U89.3
PR0_PRU1_GPIO2: length 57.6
  TOP w0.147: v1(75.64,51.05) R249.2
  BOTTOM w0.147: U89.4 81.46,86.35 80.61,85.5 80.61,84.63 81.36,83.88 81.36,80.35 82.02,79.69 82.02,71.74 80.81,70.52 80.81,65.63 84.86,61.58 84.86,56.4 79.83,51.36 79.83,46.71 79.61,46.48 79.26,46.48 79.08,46.67 79.08,50.75 77.42,52.41 75.67,52.41 75,51.74 75,51.23 75.18,51.05 v1(75.64,51.05)
PR0_PRU1_GPIO3: length 57.1
  TOP w0.147: v1(81.3,86.85) 82.23,85.92 84.9,85.92 85.35,85.47 85.35,84.86 86.19,84.02 86.19,80.94 87.16,79.96 87.16,79.78 86.84,79.45 86.84,79.27 86.97,79.14 87.15,79.14 87.48,79.47 87.66,79.47 87.79,79.34 87.79,79.15 87.46,78.83 87.46,78.65 87.59,78.52 87.77,78.52 88.1,78.84 88.28,78.84 88.72,78.41 88.72,74.58 87.56,73.42 87.56,71.5 88.37,70.68 88.37,66.04 86.44,64.11 84.31,64.11 83.85,63.65 83.85,63.24 83.98,63.11 84.47,63.11 84.6,62.98 84.6,62.8 84.47,62.67 83.98,62.67 83.85,62.54 83.85,62.36 83.98,62.23 84.47,62.23 84.6,62.1 84.6,61.92 84.47,61.79 83.98,61.79 83.85,61.66 83.85,61.47 83.98,61.35 84.47,61.35 84.6,61.22 84.6,61.03 84.47,60.9 83.98,60.9 83.85,60.77 83.85,60.32 83.12,59.58 83.12,54.83 80,51.71 v1(76.86,51.71)
  BOTTOM w0.147: v1(76.86,51.71) 76.24,51.09 76.24,50.74 75.76,50.27 R250.2 ; U89.5 v1(81.3,86.85)
PR0_PRU1_GPIO4: length 57.5
  TOP w0.147: R251.2 v1(74.42,51.05)
  BOTTOM w0.147: v1(74.42,51.05) 74.42,51.88 75.39,52.85 78.27,52.85 78.4,52.73 78.4,52.26 78.53,52.13 78.71,52.13 78.84,52.26 78.84,52.73 78.97,52.85 79.15,52.85 79.28,52.73 79.28,52.26 79.41,52.13 79.59,52.13 79.72,52.26 79.72,52.73 79.85,52.85 80.2,52.85 80.35,53 80.35,53.21 80.17,53.39 80.17,53.58 80.3,53.7 80.48,53.7 80.83,53.36 81.01,53.36 81.14,53.49 81.14,53.67 80.79,54.02 80.79,54.2 80.92,54.33 81.11,54.33 81.45,53.99 81.63,53.99 81.76,54.12 81.76,54.3 81.42,54.64 81.42,54.83 81.55,54.95 81.73,54.95 82.08,54.61 82.26,54.61 82.39,54.74 82.39,54.92 82.04,55.27 82.04,55.45 82.17,55.58 82.36,55.58 82.7,55.24 82.88,55.24 83.01,55.37 83.01,55.55 82.67,55.89 82.67,56.08 82.8,56.2 82.98,56.2 83.33,55.86 83.51,55.86 83.64,55.99 83.64,56.17 83.29,56.52 83.29,56.7 83.42,56.83 83.61,56.83 83.95,56.49 84.13,56.49 84.43,56.78 84.43,61.55 84.25,61.73 80.48,65.5 80.48,70.66 81.7,71.87 81.7,79.56 81.05,80.21 81.05,83.77 80.2,84.62 80.2,86.47 81.08,87.35 U89.6
PR0_PRU1_GPIO5: length 57.6
  TOP w0.147: v1(71.23,51.05) 72.38,52.19 80.06,52.19 82.79,54.92 82.79,59.93 v1(83.32,60.45)
  BOTTOM w0.147: U89.7 80.93,87.85 79.79,86.7 79.79,84.62 80.74,83.67 80.74,80.06 81.37,79.42 81.37,72.01 80.16,70.79 80.16,65.37 84.02,61.5 84.02,57.93 83.81,57.71 83.52,57.71 83.32,57.92 v1(83.32,60.45) ; R252.2 70.85,50.67 v1(71.23,51.05)
PR0_PRU1_GPIO6: length 57.2
  TOP w0.147: v1(81.33,89.85) 82.93,88.25 84.82,88.25 85.77,87.3 85.77,85.06 86.5,84.33 86.5,81.07 89.03,78.54 89.03,74.45 87.86,73.29 87.86,71.63 88.68,70.81 88.68,65.84 87.17,64.33 87.17,63.07 83.44,59.35 83.44,54.73 79.99,51.27 77.44,51.27 77.34,51.18 76.41,51.18 76.08,51.51 72.46,51.51 71.98,51.02 R253.2
  BOTTOM w0.147: U89.11 v1(81.33,89.85)
PR0_PRU1_GPIO8: length 57.1
  BOTTOM w0.147: R254.2 74.39,50.27 73.81,50.85 73.81,51.93 75.66,53.78 76.2,53.78 76.33,53.66 76.33,53.52 76.46,53.39 76.64,53.39 76.77,53.52 76.77,53.66 76.9,53.78 77.09,53.78 77.21,53.66 77.21,53.52 77.34,53.39 77.53,53.39 77.66,53.52 77.66,53.66 77.79,53.78 77.97,53.78 78.1,53.66 78.1,53.52 78.23,53.39 78.41,53.39 78.54,53.52 78.54,53.66 78.67,53.78 79.64,53.78 82.64,56.79 82.64,57.52 82.51,57.65 82.2,57.65 82.08,57.78 82.08,57.96 82.2,58.09 82.51,58.09 82.64,58.22 82.64,58.4 82.51,58.53 82.2,58.53 82.08,58.66 82.08,58.85 82.2,58.98 82.51,58.98 82.64,59.11 82.64,59.29 82.51,59.42 82.2,59.42 82.08,59.55 82.08,59.73 82.2,59.86 82.51,59.86 82.64,59.99 82.64,60.17 82.51,60.3 82.2,60.3 82.08,60.43 82.08,60.61 82.2,60.74 82.51,60.74 82.64,60.87 82.64,61.06 82.51,61.19 82.2,61.19 82.08,61.31 82.08,61.5 82.2,61.63 82.51,61.63 82.64,61.76 82.64,62.42 79.83,65.23 79.83,70.93 81.05,72.14 81.05,79.29 80.42,79.91 80.42,83.56 78.96,85.03 78.96,89.35 79.95,90.35 U89.12
PR0_PRU1_GPIO9: length 51.4
  BOTTOM w0.147: U89.13 79.85,90.85 78.6,89.6 78.6,84.97 80.11,83.46 80.11,79.76 80.72,79.15 80.72,72.28 79.5,71.06 79.5,65.1 81.6,63 81.6,56.66 79.36,54.42 75.53,54.42 73.47,52.37 73.47,51.03 73.21,50.77 R255.2
PR0_PRU1_GPIO10: length 49.9
  TOP w0.147: R256.2 73.2,50.68 v1(72.83,51.05)
  BOTTOM w0.147: v1(72.83,51.05) 72.83,55.05 75.32,57.53 77.5,57.53 78.11,58.14 78.11,58.88 79.47,60.24 79.47,63.23 79.62,63.39 79.62,64.52 79.18,64.96 79.18,71.2 80.4,72.41 80.4,79.02 79.8,79.62 79.8,83.36 78.25,84.9 78.25,89.83 79.77,91.35 U89.14
PR0_PRU1_GPIO11: length 72.2
  TOP w0.147: v1(80.39,103.34) 80.61,103.11 80.61,102.79 80.43,102.62 80.19,102.62 79.98,102.82 79.72,102.82 79.54,102.64 79.54,97.8 80.19,97.15 80.19,88.86 80.89,88.16 80.89,87.71 80.41,87.22 80.41,86.53 81.45,85.49 81.45,81.9 82.07,81.28 82.07,77.95 83.32,76.7 84.02,76.7 84.17,76.55 84.17,76.17 83.56,75.56 82.45,75.56 81.89,74.99 81.89,70.92 81.15,70.17 81.15,65.61 82.93,63.82 82.93,61.3 82.14,60.51 82.14,55.11 79.84,52.81 71.26,52.81 70.01,51.56 v1(70.01,51.05)
  BOTTOM w0.147: v1(80.39,103.34) 80.89,102.84 U88.11 ; v1(70.01,51.05) 69.63,50.67 R257.2
PR0_PRU1_GPIO12: length 71.9
  TOP w0.147: v1(81.3,103.34) 80.85,103.79 80.06,103.79 79.19,102.92 79.19,97.5 79.88,96.81 79.88,86.61 81.1,85.39 81.1,81.8 81.67,81.23 81.67,80.32 81.54,80.19 81.33,80.19 81.2,80.07 81.2,79.88 81.33,79.75 81.54,79.75 81.67,79.62 81.67,77.82 82.32,77.16 82.32,76.98 82.15,76.82 82.15,76.63 82.28,76.5 82.47,76.5 82.63,76.67 82.81,76.67 83.16,76.33 83.16,76.12 83.01,75.97 82.37,75.97 81.54,75.14 81.54,71.04 80.81,70.31 80.81,65.45 82.58,63.68 82.58,61.45 81.82,60.68 81.82,55.2 79.74,53.11 70.99,53.11 69.32,51.44 69.32,51.05 69.54,50.83 R258.2
  BOTTOM w0.147: U88.12 v1(81.3,103.34)
PR0_PRU1_GPIO13: length 71.8
  TOP w0.147: v1(80.39,104.34) 79.93,104.34 78.84,103.24 78.84,97.2 79.57,96.47 79.57,86.42 80.75,85.25 80.75,81.23 80.88,81.1 81.09,81.1 81.22,80.98 81.22,80.79 81.09,80.66 80.88,80.66 80.75,80.53 80.75,79.65 81.19,79.21 81.19,77.23 81.32,77.1 81.53,77.1 81.66,76.97 81.66,76.79 81.53,76.66 81.32,76.66 81.19,76.53 81.19,76.35 81.32,76.22 81.53,76.22 81.66,76.09 81.66,75.91 81.53,75.78 81.32,75.78 81.19,75.65 81.19,71.17 80.47,70.45 80.47,65.3 82.23,63.53 82.23,61.59 81.49,60.85 81.49,55.29 79.63,53.42 70.7,53.42 68.79,51.51 v1(68.79,51.05)
  BOTTOM w0.147: v1(80.39,104.34) 80.89,103.84 U88.13 ; R259.2 68.41,50.67 v1(68.79,51.05)
PR0_PRU1_GPIO14: length 72
  TOP w0.147: R260.2 70.76,50.83 70.62,50.97 70.62,51.33 71.79,52.5 79.95,52.5 82.47,55.01 82.47,60.34 83.28,61.16 83.28,63.97 81.48,65.77 81.48,70.03 82.24,70.79 82.24,74.85 82.48,75.09 83.62,75.09 84.61,76.08 84.61,76.71 84.24,77.08 83.52,77.08 82.46,78.13 82.46,81.34 81.8,82.01 81.8,85.6 80.84,86.55 80.84,87.11 81.24,87.5 81.24,88.34 80.52,89.06 80.52,97.39 79.89,98.01 79.89,101.39 81.19,102.68 81.77,102.68 82.05,102.97 82.05,103.58 v1(81.3,104.34)
  BOTTOM w0.147: U88.14 v1(81.3,104.34)
PR0_PRU1_GPIO15: length 72.5
  TOP w0.147: v1(80.39,105.34) 80.49,105.44 80.7,105.44 80.85,105.3 80.85,105.15 81.05,104.95 81.05,104.73 80.95,104.63 80.74,104.63 80.58,104.79 79.84,104.79 78.49,103.44 78.49,96.94 79.25,96.18 79.25,86.25 80.4,85.1 80.4,79.5 80.84,79.06 80.84,71.3 80.13,70.59 80.13,65.14 81.88,63.39 81.88,61.74 81.17,61.02 81.17,55.38 79.52,53.73 70.46,53.73 68.32,51.59 R261.2
  BOTTOM w0.147: v1(80.39,105.34) 80.89,104.84 U88.15
PR0_PRU1_GPIO16: length 72.1
  TOP w0.147: v1(67.83,51.05) 67.83,51.71 70.16,54.04 79.41,54.04 80.84,55.47 80.84,61.19 81.53,61.88 81.53,63.24 79.8,64.98 79.8,70.73 80.49,71.42 80.49,78.92 80.04,79.36 80.04,84.96 78.92,86.08 78.92,95.82 78.14,96.61 78.14,103.75 80.2,105.81 80.83,105.81 v1(81.3,105.34)
  BOTTOM w0.147: U88.16 v1(81.3,105.34) ; R262.2 67.19,50.87 67.37,51.05 v1(67.83,51.05)
PR0_PRU1_GPIO18: length 89.5
  TOP w0.147: v1(66.43,51.69) 66.43,51.65 R1652.2 ; v1(69.95,15.9) 69.08,15.9 68.94,16.04 R423.2
  L03_SIG1 w0.091: v1(69.95,15.9) 65.18,11.12 65.18,9.31 63.8,7.94 63.8,5.67 63.12,4.99 61.26,4.99 60.41,4.13 50.06,4.13 49.33,4.86 49.33,6.92 v1(48.64,7.61)
  L08_SIG2 w0.091: v1(66.43,51.69) 66.69,51.43 66.69,51.2 67.71,50.19 68.52,50.19 69.52,49.18 70.9,49.18 72.12,47.96 72.12,47.15 75.2,44.08 75.2,39.46 75.9,38.76 75.9,35.13 77.22,33.81 77.22,30.49 78.48,29.24 78.91,29.24 79.71,28.44 79.71,27.98 80.12,27.56 80.12,26.93 76.65,23.46 76.65,17.54 74.75,15.64 70.22,15.64 v1(69.95,15.9)
  BOTTOM w0.147: v1(48.64,7.61) 47.84,6.81 J15.70
PR0_PRU1_GPIO19: length 89.1
  TOP w0.147: R1653.2 v1(65.2,51.69) ; R420.2 71.91,16.24 v1(72.05,16.1)
  L03_SIG1 w0.091: v1(72.05,16.1) 71.04,16.1 66.59,11.66 66.59,9.82 65.64,8.86 65.64,4.57 64.8,3.73 48.87,3.73 48.21,4.38 48.21,4.4 v1(47.04,5.58)
  L08_SIG2 w0.091: v1(72.05,16.1) 74.83,16.1 76.4,17.67 76.4,23.58 79.79,26.98 79.79,27.44 79.45,27.78 78.99,27.78 78.08,28.69 77.34,28.69 76.82,29.2 76.82,33.86 75.66,35.03 75.66,38.61 74.97,39.3 74.97,43.72 74.41,44.28 73.6,44.28 71.69,46.2 71.69,47.78 70.51,48.95 69.39,48.95 68.4,49.94 67.66,49.94 66.84,50.77 66.12,50.77 v1(65.2,51.69)
  BOTTOM w0.147: J15.68 47.04,3.92 47.49,4.37 47.49,5.12 v1(47.04,5.58)
PR0_PRU1_REF_CLK: length 100.2
  TOP w0.147: R274.2 v1(28.89,37.39) ; J8.28 v1(73.27,93.04)
  L08_SIG2 w0.091: v1(73.27,93.04) 73.04,92.81 70.89,92.81 69.21,91.13 69.21,90.11 66.78,87.68 66.78,87.34 64.98,85.54 64.98,78.61 62.43,76.06 62.43,64.74 61.93,64.24 58.87,64.24 57.8,63.18 52.4,63.18 50.87,64.7 49.66,64.7 49.13,65.24 42.4,65.24 40.01,62.84 31.74,62.84 31.06,62.17 29.57,62.17 28.7,61.3 26.39,61.3 25.88,60.78 25.88,48.03 27.4,46.51 27.4,38.89 v1(28.89,37.39)
QSPI_CLK: length 34.4
  TOP w0.147: U18.6 30.27,55.11 30.16,55.21 R89.1 v1(29.66,54.6)
  L08_SIG2 w0.091: v1(29.66,54.6) 32.73,54.6 34.25,53.08 34.25,51.78 39.23,46.81 39.34,46.81 39.42,46.89 39.42,47 34.81,51.61 34.81,51.78 34.89,51.86 35.01,51.86 40.53,46.33 41.3,46.33 v1(41.73,46.76)
  BOTTOM w0.147: U80.41 41.23,46.26 v1(41.73,46.76)
QSPI_CS1: length 28.1
  TOP w0.147: v1(40.67,51.84) R86.2 40.11,52.57 U18.1
  L03_SIG1 w0.091: v1(40.67,51.84) 40.67,49 42.4,47.27 42.4,36.69 42.05,36.34 42.05,35.69 43.13,34.61 46.4,34.61 v1(46.74,34.95)
  BOTTOM w0.147: v1(46.74,34.95) 46.84,34.95 47.06,34.74 TP46.1 R99.1
QSPI_D0: length 31.6
  TOP w0.147: R439.2 R1667.1 v1(27.79,58.41)
  L08_SIG2 w0.091: v1(27.79,58.41) 28.58,57.61 37.46,57.61 38.17,56.9 38.17,52.24 38.25,52.16 38.37,52.16 38.45,52.24 38.45,54.53 38.54,54.62 38.65,54.62 38.73,54.54 38.73,48.75 v1(40.73,46.76)
  BOTTOM w0.147: U80.39 40.23,46.26 v1(40.73,46.76)
QSPI_D1: length 31.9
  TOP w0.147: R440.2 R1668.1 42.83,53.11 v1(42.71,52.99)
  L08_SIG2 w0.091: v1(42.71,52.99) 42.71,54.64 42.62,54.73 41.31,54.73 41.22,54.64 41.22,54.47 41.3,54.39 42.13,54.39 42.21,54.31 42.21,54.2 42.13,54.12 41.3,54.12 41.22,54.04 41.22,53.92 41.3,53.84 42.13,53.84 42.21,53.76 42.21,53.65 42.13,53.57 41.3,53.57 41.22,53.49 41.22,53.38 41.3,53.3 42.13,53.3 42.21,53.21 42.21,53.1 42.13,53.02 41.3,53.02 41.22,52.94 41.22,52.83 41.3,52.75 42.13,52.75 42.21,52.67 42.21,52.55 42.13,52.47 41.3,52.47 41.22,52.39 41.22,48.28 42.61,46.89 42.61,42.49 42.07,41.95 39.83,41.95 39.28,42.51 v1(39.28,44.91)
  BOTTOM w0.147: U80.38 v1(39.28,44.91)
QSPI_D2: length 32.2
  TOP w0.147: R441.2 R84.2 42.83,55.58 v1(42.29,56.12)
  L08_SIG2 w0.091: v1(42.29,56.12) 40.81,56.12 39.29,54.61 39.29,49.78 39.37,49.7 39.49,49.7 39.57,49.78 39.57,53.78 39.65,53.86 39.76,53.86 39.84,53.78 39.84,49.27 42.22,46.89 42.22,45.28 41.89,44.94 40.49,44.94 39.95,45.48 38.75,45.48 38.17,44.9 v1(38.17,43.62)
  BOTTOM w0.147: v1(38.17,43.62) 38.47,43.32 U80.36
QSPI_D3: length 32.7
  TOP w0.147: R442.2 R85.2 v1(27.56,54.73)
  L08_SIG2 w0.091: v1(27.56,54.73) 28.33,53.96 30.95,53.96 37.2,47.71 37.2,47.59 37.12,47.51 37,47.51 33.42,51.1 33.27,51.1 33.19,51.02 33.19,50.9 37.5,46.58 37.5,43.08 v1(37.21,42.79)
  BOTTOM w0.147: v1(37.21,42.79) 37.67,42.32 U80.34
R_LED2_0: length 6.6
  BOTTOM w0.147: J7.11 109.27,77.15 107.54,78.88 105.96,78.88 105.6,79.24 R216.1
RBIAS2: length 5.1
  BOTTOM w0.147: R215.1 TP63.1 94.74,65.27 94.16,65.84 U35.12
RESETZ: length 46.9
  L03_SIG1 w0.091: v1(54.33,52.17) 48.6,57.9 48.6,63.46 49.19,64.05 49.19,71.45 51.03,73.3 51.03,78.59 50.23,79.39 50.23,84.4 52.29,86.46 52.29,87.97 51.84,88.43 51.84,89.73 v1(52.07,89.95)
  BOTTOM w0.147: v1(54.33,52.17) 53.91,51.74 R185.1 ; U76.2 53.06,89.51 R428.2 52.57,89.45 v1(52.07,89.95)
RESETZ_HSEC: length 8.4
  TOP w0.147: R419.2 v1(67.93,9.64)
  BOTTOM w0.147: J15.120 67.84,4.91 67.21,5.54 67.21,8.92 v1(67.93,9.64)
RJ45_ETH0_D0_N: length 9.7
  BOTTOM w0.108: J7.10 99.66,74.02 99.66,73.33 98.33,72 96.74,72 95.7,70.95 93.43,70.95 93.32,70.84 U35.2
RJ45_ETH0_D0_P: length 9.7
  BOTTOM w0.108: J7.9 98.86,73.98 99.2,73.98 99.37,73.82 99.37,73.45 98.21,72.29 96.62,72.29 95.58,71.24 93.43,71.24 93.32,71.34 U35.1
RJ45_ETH0_D1_N: length 9.4
  BOTTOM w0.108: J7.8 99.66,71.48 99.66,70.56 98.55,69.45 93.43,69.45 93.32,69.34 U35.5
RJ45_ETH0_D1_P: length 9.4
  BOTTOM w0.108: J7.7 98.86,71.44 99.2,71.44 99.37,71.28 99.37,70.68 98.43,69.74 93.43,69.74 93.32,69.84 U35.4
RJ45_ETH0_D2_N: length 9.8
  BOTTOM w0.108: J7.6 99.66,68.94 99.66,67.96 98.71,67.01 96.93,67.01 95.99,67.95 93.43,67.95 93.32,67.84 U35.8
RJ45_ETH0_D2_P: length 9.8
  BOTTOM w0.108: J7.5 98.86,68.9 99.2,68.9 99.37,68.74 99.37,68.08 98.59,67.3 97.05,67.3 96.11,68.24 93.43,68.24 93.32,68.34 U35.7
RJ45_ETH0_D3_N: length 10.1
  BOTTOM w0.108: J7.4 99.66,66.4 99.66,65.67 98.49,64.5 98.39,64.5 98.39,64.5 97.28,64.5 96.52,64.5 94.57,66.45 93.43,66.45 93.32,66.34 U35.11
RJ45_ETH0_D3_P: length 10.1
  BOTTOM w0.108: J7.3 98.86,66.36 99.2,66.36 99.37,66.2 99.37,65.79 98.37,64.79 98.27,64.79 98.27,64.79 97.4,64.79 97.4,64.79 96.64,64.79 94.69,66.74 93.43,66.74 93.32,66.84 U35.10
RSVD_T4: length 5.9
  TOP w0.147: U1.T4 v1(55.38,34.43)
  BOTTOM w0.114: 57.38,33.37 57.38,33.86 57.21,34.03 55.78,34.03
  BOTTOM w0.147: R82.1 58.11,31.62 57.38,32.34 57.38,33.37 ; 55.78,34.03 v1(55.38,34.43)
RSVD_U1: length 3.9
  TOP w0.147: R186.1 52.03,31.25 52.83,32.04 52.83,33.48 U1.U1
RSVD_U3: length 4.6
  TOP w0.147: TP59.1 53.61,31.41 54.49,32.29 54.49,32.9 54.59,33 54.59,33.64 U1.U3
RSVD_V2: length 5.8
  TOP w0.147: U1.V2 54.18,32.59 52.72,31.13 52.72,28.83 52.7,28.82 TP60.1
SAFETY_ERRORN: length 89
  TOP w0.147: Q20.1 76.62,30.48 77.03,30.06 77.57,30.06 78.02,29.6 v1(78.02,27.85) ; U1.D4 v1(55.38,44.83)
  L08_SIG2 w0.091: v1(78.02,27.85) 77.9,27.97 77.58,27.97 76.4,29.16 76.4,33.94 75.41,34.93 75.41,38.36 74.74,39.03 74.74,43.57 74.3,44.02 73.43,44.02 71.29,46.16 71.29,47.46 70.7,48.05 69.94,48.05 68.27,49.73 67.5,49.73 66.84,50.39 65.71,50.39 64.41,51.7 64.41,52.25 63.54,53.11 62.09,53.11 60.83,51.85 60.83,48.26 59.77,47.2 59.77,45.47 59.54,45.24 59.24,45.24 58.97,44.97 58.97,44.67 58.74,44.44 55.83,44.44 55.44,44.83 v1(55.38,44.83)
  BOTTOM w0.114: v1(55.38,44.83) 54.98,45.23 52.8,45.23
  BOTTOM w0.147: 52.8,45.23 52.72,45.23 52.34,45.6 52.34,46.9 TP56.1 ; R435.2 105.65,27.31 105.41,27.06 90.98,27.06 90.7,26.78 79.09,26.78 v1(78.02,27.85)
SOC_BOOTMODE0: length 84.1
  L08_SIG2 w0.091: v1(46.06,44.57) 46.06,45.7 45.18,46.58 44.22,46.58 42.3,48.5 42.3,50.25 43.81,51.76 43.81,55.21 43.36,55.67 43.36,56.66 41.53,58.49 41.53,62.11 42.86,63.44 43.02,63.6 49.04,63.6 49.23,63.79 50.33,63.79 53.44,60.68 56.78,60.68 59.28,63.19 60.63,63.19 61.11,62.7 63.49,62.7 65.32,64.54 65.32,76.26 66.55,77.48 66.55,80.15 65.73,80.97 65.73,84.51 67.2,85.98 v1(67.81,85.98)
  BOTTOM w0.147: R119.2 46.29,36.13 45.65,36.77 45.65,38.96 47.21,40.53 47.21,41.42 46.79,41.84 46.79,42.94 46.06,43.67 v1(46.06,44.57) ; v1(67.81,85.98) 67.49,86.3 U48.15
SOC_BOOTMODE1: length 83.2
  L08_SIG2 w0.091: v1(45.37,45.26) 45.37,46 45.01,46.37 44.11,46.37 42.03,48.45 42.03,50.36 43.62,51.96 43.62,55.07 43.1,55.58 43.1,56.53 41.25,58.37 41.25,62.23 42.9,63.88 48.82,63.88 49.03,64.09 50.42,64.09 53.56,60.95 56.67,60.95 59.17,63.46 60.74,63.46 61.22,62.97 63.38,62.97 65.02,64.61 65.02,76.25 66.35,77.57 66.35,80.08 65.54,80.89 65.54,80.9 65.53,80.91 65.52,80.91 65.52,84.73 v1(67.81,87.02)
  BOTTOM w0.147: v1(67.81,87.02) 67.49,86.7 U48.14 ; v1(45.37,45.26) 46.04,45.26 46.57,44.73 46.57,43.78 47.2,43.16 47.2,41.95 47.54,41.61 47.54,40.44 46.82,39.72 R122.2
SOC_BOOTMODE2: length 48
  TOP w0.147: R150.2 60.54,52.74 v1(60.54,53.61)
  L03_SIG1 w0.091: v1(60.54,53.61) 59.24,54.91 59.24,57.73 58.58,58.39 58.58,64.92 60.86,67.2 60.86,69.82 60.39,70.29 59.11,70.29 58.34,71.07 58.34,78.73 60.33,80.72 60.33,82.43 61.85,83.95 61.85,88.58 v1(62.86,89.59)
  BOTTOM w0.147: v1(62.86,89.59) 65.37,89.59 66.75,88.2 U48.13
SOC_BOOTMODE3: length 50
  L03_SIG1 w0.091: v1(59.37,53.61) 58.8,54.18 58.8,57.8 58.34,58.26 58.34,64.99 60.59,67.24 60.59,69.73 60.28,70.03 59,70.03 58.06,70.97 58.06,78.83 60.07,80.83 60.07,82.54 61.59,84.06 v1(61.59,89.59)
  BOTTOM w0.147: U48.12 66.15,87.88 65.04,89 62.18,89 v1(61.59,89.59) ; v1(59.37,53.61) 60.72,52.27 60.72,51.64 R151.2
SOC_CLK_IN: length 1.4
  TOP w0.147: U43.4 R176.1
SOC_CLK_XTAL_IN: length 4.3
  TOP w0.147: Y1.1 47.22,30.99 47.39,30.82 C184.1 49.75,30.82 50.01,31.08 R178.1
SOC_CLK_XTAL_OUT: length 5.8
  TOP w0.147: R179.1 49.94,33.54 49.59,33.89 C185.1 48.25,33.89 47.74,34.4 46.15,34.4 46.02,34.28 Y1.3
SOC_I2C0_SCL: length 35.6
  TOP w0.147: R135.1 v1(62.62,51.73)
  BOTTOM w0.147: R159.2 48.48,70.26 U26.4 45.6,70.26 45.18,69.85 45.18,67.49 46.13,66.54 47.34,66.54 47.97,65.9 47.97,59.41 52.55,54.84 60.22,54.84 61.31,53.74 61.31,53.04 v1(62.62,51.73)
SOC_I2C0_SDA: length 30.8
  BOTTOM w0.147: R136.1 63.91,52.53 61.07,55.37 52.71,55.37 48.43,59.65 48.43,62.86 49.18,63.61 R158.2 U26.7
SOC_I2C2_SCL: length 119.4
  TOP w0.147: v1(66.54,76.31) 66.09,76.31 65.93,76.47 58.5,76.47 56.96,74.93 v1(56.96,74.37) ; U1.C7 v1(57.78,45.63) ; R156.2 v1(54.41,49.14) ; U46.3 v1(49.14,77.46)
  L03_SIG1 w0.091: v1(54.41,49.14) 54.76,49.49 54.76,52.79 49.97,57.58 v1(49.97,61.46) 49.97,62 49.52,62.45 49.52,64.14 50.46,65.08 50.46,70.67 52.23,72.44 55.27,72.44 56.44,73.61 56.44,73.86 v1(56.96,74.37)
  L08_SIG2 w0.091: v1(54.41,49.14) 54.74,49.14 55.52,48.35 55.82,48.35 56.59,47.58 56.59,46.26 56.81,46.04 57.37,46.04 v1(57.78,45.63) ; v1(56.96,74.37) 56.47,74.86 52.54,74.86 49.93,77.46 v1(49.14,77.46) ; v1(89.75,61.46) 89.75,60.48 85.91,56.63 81.44,56.63 80.23,55.43 79.08,55.43 78.3,54.65 71.79,54.65 70.45,55.98 69.42,55.98 69,56.41 67.6,56.41 66.85,57.16 66.85,68.65 67.03,68.82 67.03,75.83 v1(66.54,76.31)
  BOTTOM w0.147: U60.29 56.46,73.87 v1(56.96,74.37) ; U27.8 v1(49.97,61.46) ; v1(89.75,61.46) 89.75,60.55 89.09,59.89 U13.5 89.09,58.75 89.44,58.4 89.77,58.4 90.99,59.62 U12.5 ; U59.15 v1(66.54,76.31)
SOC_I2C2_SDA: length 117.3
  TOP w0.147: U1.B7 v1(57.78,46.43) ; v1(68.07,76.31) 67.61,76.77 58.12,76.77 56.47,75.12 56.47,73.93 v1(56.96,73.44) ; v1(55.73,49.14) 55.55,49.31 R157.2 ; U46.2 v1(49.14,76.19)
  L03_SIG1 w0.091: v1(56.96,73.44) 55.6,72.09 52.4,72.09 50.73,70.42 50.73,64.75 49.97,63.99 v1(49.97,62.73) 50.55,62.14 50.55,57.72 54.94,53.33 54.94,49.92 v1(55.73,49.14)
  L08_SIG2 w0.091: v1(49.14,76.19) 50.71,76.19 52.38,74.52 55.88,74.52 v1(56.96,73.44) ; v1(87.26,61.42) 87.74,60.94 87.74,60 85.66,57.93 78.93,57.93 77.33,56.33 72.04,56.33 71.49,55.78 71.2,55.78 70.79,56.19 70.79,56.67 69.8,57.66 67.67,57.66 67.36,57.97 67.36,68.16 67.56,68.36 67.56,75.8 v1(68.07,76.31) ; v1(55.73,49.14) 56.01,49.14 56.88,48.27 57.29,48.27 58.17,47.39 58.17,47.07 57.78,46.68 v1(57.78,46.43)
  BOTTOM w0.147: U12.4 90.96,59.12 89.87,58.03 89.02,58.03 88.59,58.45 U13.4 88.59,60.58 88.37,60.81 87.87,60.81 v1(87.26,61.42) ; U27.7 v1(49.97,62.73) ; U59.2 v1(68.07,76.31) ; U60.30 v1(56.96,73.44)
SOC_INTN: length 36.5
  TOP w0.147: v1(48.64,64.31) 47.99,64.96 U20.2
  L03_SIG1 w0.091: v1(48.64,64.31) 48.64,64.69 48.53,64.79 48.53,80.68 49.92,82.07 49.92,84.49 52.01,86.58 52.01,87.9 51.61,88.3 51.61,89.9 v1(50.16,91.35)
  BOTTOM w0.147: v1(50.16,91.35) 50.52,91.35 50.7,91.54 R544.2 50.7,92.25 52.06,93.6 U76.5
SOC_MMC0_CLK: length 13.6
  TOP w0.147: U1.B6 v1(56.98,46.43) ; RA2.5 50.92,50.22 50.92,50.45 v1(51.03,50.55) 50.92,50.66 TP49.1
  L08_SIG2 w0.091: v1(56.98,46.43) 57.37,46.82 57.37,47.39 56.13,48.63 55.63,48.63 54.44,49.82 54.33,49.82 54.17,49.66 54.05,49.66 53.97,49.74 53.97,49.85 54.13,50.01 54.13,50.13 54.05,50.21 53.94,50.21 53.78,50.05 53.66,50.05 53.58,50.13 53.58,50.24 53.75,50.4 53.75,50.52 53.23,51.03 52.21,51.03 51.73,50.55 v1(51.03,50.55)
  BOTTOM w0.147: v1(51.03,50.55) 50.92,50.66 50.92,50.77 RA3.5
