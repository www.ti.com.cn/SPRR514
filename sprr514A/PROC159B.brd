# Allegro board PROC159B.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
R1679  10K  [RES0201_0-5]  42.78 40.04 180 top
R3832  220E  [RES0402_0-5]  78.31 33.5 270 top
R3833  220E  [RES0402_0-5]  102.75 57.68 180 top
R3834  220E  [RES0402_0-5]  73.15 77.05 180 top
R3835  220E  [RES0402_0-5]  12.8 49.48 0 top
R3836  10K  [RES0402_0-5]  45.03 40.4 0 bottom
R3842  1K_1%  [RES0402_0-5]  60.32 55.59 0 top
R3843  10K  [RES0402_0-5]  65.25 60.38 90 bottom
R3844  10K  [RES0402_0-5]  63.38 63.3 180 top
R3849  10K  [RES0402_0-5]  95.37 88.35 0 top
R3852  10K  [RES0402_0-5]  95.37 101.34 0 top
R3858  1K_1%  [RES0402_0-5]  47.8 92.35 180 top
R3861  10K  [RES0402_0-5]  79.51 101.65 0 bottom
R3864  10K  [RES0402_0-5]  80.07 88.84 180 bottom
R3865  0E  [RES0402_0-5]  49.71 46.27 180 top
R3866  2.2K  [RES0402_0-5]  76.4 42.56 270 bottom
R3867  2.2K  [RES0402_0-5]  76.77 33.91 90 bottom
R3870  10K  [RES0402_0-5]  77.9 42.56 270 bottom
R3871  10K  [RES0402_0-5]  78.89 34.18 180 bottom
R3872  1K_1%  [RES0402_0-5]  50.8 92.37 270 top
R3873  10K  [RES0402_0-5]  55.28 81.33 90 top
R3874  1K_1%  [RES0402_0-5]  75.15 95.65 90 bottom
R3875  1K_1%  [RES0402_0-5]  77.24 98.22 90 top
R3876  0E  [RES0402_0-5]  46.4 46.09 180 top
R3877  0E  [RES0402_0-5]  46.4 47.36 180 top
R3878  10K  [RES0201_0-5]  36.38 35.63 90 top
R3879  0E  [RES0402_0-5]  35.04 35.77 270 top
R3880  0E  [RES0402_0-5]  49.77 47.23 0 bottom
R3881  0E  [RES0402_0-5]  47.49 47.23 180 bottom
R3882  4.7K  [RES0402_0-5]  49.78 42.03 0 bottom
RA2  0E  [RESA_EXB28V_0402-4_0-5]  49.65 49.39 0 top
RA3  0E  [RESA_EXB28V_0402-4_0-5]  49.6 51.65 0 bottom
RA4  0E  [RESA_EXB28V_0402-4_0-5]  46.1 49.39 0 top
RA5  0E  [RESA_EXB28V_0402-4_0-5]  46.05 51.65 0 bottom
SW1  TDA01H0SB1R  [SW_TDA01H0S_240X90_SMD_2-3]  33.92 66.19 0 top
SW4  CAS-120TA  [SW3_CAS-120TA_215X100_SMD]  14.48 61.2 0 top
SW5  TDA01H0SB1R  [SW_TDA01H0S_240X90_SMD_2-3]  21.09 70.75 180 top
SW6  416131160804  [SW8_416131160804_260X230_SMD_2-7]  60.28 86.61 90 top
SW7  CAS-120TA  [SW3_CAS-120TA_215X100_SMD]  38.3 26.02 90 top
SW8  CAS-120TA  [SW3_CAS-120TA_215X100_SMD]  32.51 25.94 90 top
SW9  CAS-D20TA  [SW6_CAS-D20A_210X150_SMD]  29.21 19.29 90 top
SW10  430182050816  [SW4_430182050816_240X240_SMD_5-2]  50.44 100.82 90 top
SW11  430182050816  [SW4_430182050816_240X240_SMD_5-2]  57.4 100.82 90 top
SW12  430182050816  [SW4_430182050816_240X240_SMD_5-2]  64.36 100.82 90 top
SW13  CAS-120TA  [SW3_CAS-120TA_215X100_SMD]  36.94 19.71 180 top
SW14  TDA01H0SB1R  [SW_TDA01H0S_240X90_SMD_2-3]  47.31 86.97 90 top
SW15  TDA01H0SB1R  [SW_TDA01H0S_240X90_SMD_2-3]  62.89 57.91 270 top
SW16  TDA01H0SB1R  [SW_TDA01H0S_240X90_SMD_2-3]  50.8 86.5 90 top
TP1  -  [TP40_SMD]  99.08 11.22 270 bottom
TP2  -  [TP40_SMD]  104.9 19.93 90 top
TP5  -  [TP40_SMD]  99.56 55.61 0 top
TP6  -  [TP40_SMD]  101.87 55.94 90 top
TP7  -  [TP20_SMD]  101.7 46.03 0 bottom
TP8  -  [TP20_SMD]  102.23 46.72 90 bottom
TP10  -  [TP40_SMD]  104.82 30.37 0 top
TP13  -  [TP20_SMD]  110.02 35.18 90 top
TP15  -  [TP20_SMD]  110.1 46.22 90 top
TP16  -  [TP20_SMD]  103.75 46.08 90 top
TP17  -  [TP20_SMD]  108.58 54.19 180 top
TP18  -  [TP20_SMD]  104.77 47.1 90 top
TP19  -  [TP40_SMD]  105.74 32.3 0 top
TP20  -  [TP40_SMD]  106.68 54.98 180 bottom
TP21  -  [TP40_SMD]  57.58 82.13 180 top
TP23  THRU HOLE  [TP_40X65]  112.46 100.15 0 top
TP24  THRU HOLE  [TP_40X65]  13.02 74.52 0 top
TP25  THRU HOLE  [TP_40X65]  12.38 14.39 0 top
TP26  THRU HOLE  [TP_40X65]  45.4 23.56 0 top
TP27  -  [TP40_SMD]  106.32 58.69 180 bottom
TP28  -  [TP40_SMD]  82.89 49.91 0 top
TP29  THRU HOLE  [TP_40X65]  103.96 86.44 90 top
TP30  -  [TP20_SMD]  107.49 86.44 180 top
TP31  -  [TP20_SMD]  29.66 54.6 180 bottom
TP32  -  [TP20_SMD]  35.68 39.74 180 bottom
TP33  -  [TP20_SMD]  27.79 58.41 180 bottom
TP34  -  [TP20_SMD]  42.71 52.99 180 bottom
TP35  -  [TP20_SMD]  42.29 56.12 180 bottom
TP36  -  [TP20_SMD]  27.56 54.73 180 bottom
TP37  -  [TP20_SMD]  32.6 49.39 180 bottom
TP38  -  [TP20_SMD]  26.31 42.3 180 bottom
TP39  -  [TP20_SMD]  37.08 44.65 180 bottom
TP40  -  [TP20_SMD]  26.31 44.84 180 bottom
TP41  -  [TP20_SMD]  26.31 43.57 180 bottom
TP42  -  [TP20_SMD]  30.48 48.63 180 bottom
TP43  -  [TP20_SMD]  33.93 49.36 180 bottom
TP44  -  [TP20_SMD]  37.08 46.22 180 bottom
TP45  -  [TP40_SMD]  47.5 37.38 0 top
TP46  -  [TP40_SMD]  47.06 33.85 180 bottom
TP47  -  [TP20_SMD]  32.35 43.16 0 bottom
TP48  -  [TP30_SMD]  43.97 46.86 180 bottom
TP49  -  [TP30_SMD]  50.92 51.42 0 top
TP50  -  [TP30_SMD]  36.56 48.58 180 bottom
TP51  -  [TP40_SMD]  21.2 56.63 0 top
TP52  -  [TP40_SMD]  37.33 61.06 180 bottom
TP53  -  [TP40_SMD]  57.19 50.54 180 bottom
TP54  -  [TP40_SMD]  43.07 57.39 0 top
TP55  -  [TP40_SMD]  37.38 59.02 180 bottom
TP56  -  [TP40_SMD]  51.86 47.39 180 bottom
TP57  -  [TP40_SMD]  52.81 30.22 90 bottom
TP58  -  [TP40_SMD]  52.34 51.83 180 bottom
TP59  -  [TP40_SMD]  53.61 30.01 90 top
TP60  -  [TP40_SMD]  52.7 28.03 90 top
TP61  -  [TP40_SMD]  94.83 72.19 180 bottom
TP62  -  [TP40_SMD]  88.58 78.41 180 bottom
TP63  -  [TP40_SMD]  94.74 64.25 180 bottom
TP66  -  [TP40_SMD]  15.62 98.16 180 top
TP67  -  [TP40_SMD]  20.44 98.29 180 top
TP68  -  [TP40_SMD]  17.93 90.59 0 bottom
TP69  -  [TP40_SMD]  15.77 90.54 0 bottom
TP70  -  [TP40_SMD]  15.77 88.4 0 bottom
TP71  -  [TP40_SMD]  17.93 88.46 0 bottom
TP72  -  [TP40_SMD]  30.22 83.55 0 bottom
TP73  -  [TP40_SMD]  32.51 83.55 180 bottom
TP74  THRU HOLE  [TP_40X65]  12.38 81.38 0 top
TP75  -  [TP40_SMD]  87.14 34.58 180 top
TP76  THRU HOLE  [TP_40X65]  83.81 45.45 270 top
TP77  THRU HOLE  [TP_40X65]  12.46 41.02 90 top
TP78  -  [TP20_SMD]  17.96 26.32 0 top
TP79  -  [TP40_SMD]  87.8 30.31 0 top
TP80  -  [TP40_SMD]  97.66 87.54 0 top
TP81  -  [TP40_SMD]  104.34 7.98 180 top
TP82  -  [TP40_SMD]  92.15 62.62 0 top
TP83  -  [TP20_SMD]  100.46 96.93 270 top
TP84  -  [TP20_SMD]  100.46 97.92 270 top
TP85  -  [TP40_SMD]  85.67 48.97 0 top
TP86  -  [TP20_SMD]  51.73 37.16 180 bottom
U1  XAM263P4ASOKFZCZ  [BGA324_31-49_590X590_1-4]  60.18 40.03 0 top
U2  SN74AHC1G02DRLR  [SOT553-5_0-6]  103.28 12.99 90 top
U3  TPS22965DSGT  [WSON8_19-68_80X80_0-8]  101.39 18.3 180 top
U4  TPS2121RUXT  [VQFNHR12_TPS2121_80X100_1]  95.27 17.29 180 top
U5  TPS61089RNRR  [VQFN11_TPS61089_100X80_1]  90.27 26.86 180 top
U7  TPS6538600QDCARQ1  [HTSSOP48_19-68_500X245_1-2]  103.44 41.14 90 top
U8  SN74CB3Q3257PWR  [TSSOP16_25-59_205X180]  62.24 14.69 90 top
U9  TPS62903-Q1  [VQFNHR9_TPS62903_80X90_1-1]  91.1 57.5 0 top
U10  TPS62177DQCR  [WSON10_19-68_80X120_0-8]  53.44 81.11 90 bottom
U12  INA228AIDGSR  [MSOP10_19-68_120X120_1-1]  94.19 58.62 0 bottom
U13  INA228AIDGSR  [MSOP10_19-68_120X120_1-1]  88.09 57.12 270 bottom
U14  TPS62097RWKT  [VQFNHR11_TPS62097_80X80_1]  100.38 86.98 180 bottom
U15  TLV75511PDQNR  [X2SON4_TLV71318P_40X40_0-4]  105.95 88.35 180 top
U16  TPS22918DBVR  [SOT23-6]  91.33 81.66 180 bottom
U17  TUSB320LAIRWBR  [X2QFN12_TUSB322I_60X60_0-4]  101.8 13.33 270 bottom
U18  W25N01GVZEAG  [WSON8_49-99_320X240_0-8]  35.15 54.47 180 top
U19  IS25LX256-LHLE  [TPBGA24_39-37_240X320_1-2]  31.85 42.66 180 top
U20  SN74CB3Q3257PWR  [TSSOP16_25-59_205X180]  48.67 63.33 0 top
U21  SN74LVC1G08DBVRE4  [SOT23-5]  33.11 36.27 0 bottom
U22  SN74LVC1G08DBVRE4  [SOT23-5]  15.36 52.31 180 top
U23  TPS22918DBVR  [SOT23-6]  15.26 56.25 0 top
U24  TPD6E001RSER  [UQFN10_19-68_80X60_0-6]  28.44 50.53 0 bottom
U25  TPD2E001DRLR  [SOT553-5_0-6]  30.22 57.25 180 bottom
U26  SN74CB3Q3257PWR  [TSSOP16_25-59_205X180]  44.61 69.94 180 bottom
U27  TMP411ADR  [SOIC8_1-8]  48.64 63.36 0 bottom
U28  CAT24M01WI-GT3  [SOIC8_1-8]  110.69 89.67 90 bottom
U29  TCAN1043ADYYRQ1  [SOT23-14_1-1]  20.29 23.41 180 top
U30  SN74CB3Q3257PWR  [TSSOP16_25-59_205X180]  34.68 61.42 0 top
U31  ISO7220CDR  [SOIC8]  45.18 88.31 0 bottom
U32  ISO6721BQDRQ1  [SOIC8_1-8]  31.02 77.14 90 bottom
U33  SN74CB3Q3257PWR  [TSSOP16_25-59_205X180]  31.64 30.85 0 bottom
U35  DP83869HMRGZT  [QFN48_19-68_280X280_1_EP4-2]  89.17 68.59 180 bottom
U36  SN74LVC1G08DBVRE4  [SOT23-5]  80.76 40.02 90 top
U39  SN74LVC1G08DBVRE4  [SOT23-5]  74.49 100.32 0 bottom
U41  LMK1C1103PWR  [TSSOP8_25-59_125X180_1-2]  22.32 35.51 0 top
U42  25.000MHz  [OSC4_ASEK_130X100_SMD_1-2]  18.31 41.28 180 top
U43  SN74LV1T34DCKR  [SC70-5_1-1]  42.25 30.02 0 top
U44  SN74CB3Q3257PWR  [TSSOP16_25-59_205X180]  31.57 69.46 0 bottom
U45  TLIN2029-Q1  [SOIC8_1-8]  20.56 66.19 180 top
U46  ISO1641BD  [SOIC8_1-8]  45.08 76.82 180 top
U47  TCA6408ARGTR  [QFN16_19-68_120X120_1_EP1-6]  61.72 80.73 270 top
U48  SN74AVC4T245RSVR  [UQFN16_TMUX1574_70X100_0-6]  65.55 86.5 90 bottom
U49  SN74LVC1G08DBVRE4  [SOT23-5]  67.93 96.15 270 bottom
U50  SN74LVC1G17DCKR  [SC70-5]  61.57 92.18 0 bottom
U51  TPS79601DRBR  [SON8_25-59_130X130_1]  18.03 101.46 90 top
U52  TM4C1294NCPDTT3R  [TQFP128_15-74_550X550_1-2]  28.54 95.11 270 bottom
U53  TPD4E004DRYR  [SON6_19-68_40X60_PB_0-6]  13.46 95.11 180 bottom
U54  ISO7221CDR  [SOIC8_1-8]  45.21 94.35 180 bottom
U55  LM4040B25IDCKR  [SC70-5_1-1]  26.19 95.62 270 top
U56  ISO1641BD  [SOIC8_1-8]  45.08 81.87 0 bottom
U57  ISO6760DW  [SOIC16_W]  38.08 102.08 0 top
U58  ISO7220CDR  [SOIC8]  19.14 77 270 bottom
U59  TPIC2810D  [SOIC16_1-8]  67.18 73.14 180 bottom
U60  TCA6424ARGJR  [QFN32_19-68_200X200]  56.21 69.99 180 bottom
U61  TPD4E001DBVR  [SOT23-6]  21.97 12.43 90 top
U62  TPD4E001DBVR  [SOT23-6]  21.97 12.43 90 bottom
U63  TPD4E001DBVR  [SOT23-6]  27.81 12.43 90 top
U64  TPD4E001DBVR  [SOT23-6]  27.81 12.43 90 bottom
U65  TPD4E001DBVR  [SOT23-6]  38.1 12.43 90 bottom
U66  TLV75801PDRVR  [SON6_25-59_85X85_0-8]  89.23 45.57 0 top
U67  OPA4350EA/250  [QSOP16_25_200X160_1-8]  31.75 24.57 0 bottom
U68  TPD4E001DBVR  [SOT23-6]  32.89 12.43 90 bottom
U69  TPD4E001DBVR  [SOT23-6]  32.89 12.43 90 top
U70  TMUX1136DQAR  [USON10_TMUX1204_40X100_0-6]  59.56 24.92 270 bottom
U72  SN74CB3Q3257PWR  [TSSOP16_25-59_205X180]  55.37 14.49 270 top
U73  SN74CB3Q3257PWR  [TSSOP16_25-59_205X180]  49.5 14.49 270 top
U74  TMUX1136DQAR  [USON10_TMUX1204_40X100_0-6]  64.76 24.99 270 bottom
U75  TMUX1136DQAR  [USON10_TMUX1204_40X100_0-6]  52.7 24.99 270 bottom
U76  SN74LVC3G07QDCURQ1  [VSSOP8_19-68_85X95]  52.81 92.85 90 bottom
U78  SN74LVC1G11DCKR  [SC70-6]  81.19 33.37 0 top
U79  SN74LVC1G08DBVRE4  [SOT23-5]  83.49 29.94 0 top
U80  TS3DDR3812RUAR  [TQFN42_19-68_140X360_0-8]  40.98 40.32 180 bottom
U81  TMUX154EDGSR  [MSOP10_19-68_120X120_1-1]  73.94 28.88 180 bottom
U82  TS3DDR3812RUAR  [TQFN42_19-68_140X360_0-8]  68.71 60.39 0 bottom
U84  TS3DDR3812RUAR  [TQFN42_19-68_140X360_0-8]  91.6 88.85 180 top
U85  TS3DDR3812RUAR  [TQFN42_19-68_140X360_0-8]  91.6 101.84 180 top
U87  TS3DDR3812RUAR  [TQFN42_19-68_140X360_0-8]  76.47 60.39 180 top
U88  TS3DDR3812RUAR  [TQFN42_19-68_140X360_0-8]  83.84 101.84 0 bottom
U89  TS3DDR3812RUAR  [TQFN42_19-68_140X360_0-8]  83.84 88.85 0 bottom
U90  TMUX154EDGSR  [MSOP10_19-68_120X120_1-1]  77.4 38.24 90 bottom
Y1  25.000MHz  [XTAL4_ABM10W_100X80_SMD_0-6]  46.62 32.59 90 top
Y2  16.000MHZ  [XTAL4_NX3225GA_130X100_SMD_0-9]  25.52 82.79 180 bottom

## Library data of the parts
C1-C20 C22 C23 C30-C38 C43-C62 C64-C86 C89-C164 C166-C193 C195-C197 C199 C206-C214 C216 C217 C219-C222 C225 C226 C230-C309 C314-C316 C318-C324 C329-C338 C340 C341 C344-C352 C355-C380 C3743-C3746 = CAP
D1 D2 = DIODE_TVS_DUAL
D3 D6 D7 = DIODE
FB1 = INDUCTOR_FERRITE
FL1-FL7 = EMIFILTER_IND
J1 = CON_USB-C_24_1240183621
J2 J3 J5 J10 = HEADER_3X1
J4 = CON_SDCARD_10_DM3BT-DSF-PEJS
J6 = HEADER_5X2
J7 = CON_RJ45-14_LPJG16314A4NL
J8 = CON_BTOB_24X2_M_SH4
J9 J12 J16-J22 = HEADER_2X1
J11 = CON_FLEX_40X1_FH12A-40S-0.5SH
J13 = CON_USB_MINI-B11
J14 = HEADER_2X2
J15 = CON_EDGE_180_HSEC8-180
L3-L7 = INDUCTOR
LD1-LD22 = DIODE_LED
Q2-Q4 Q6-Q8 = MOSFET_BSS138W
Q5 Q9-Q11 Q20 Q21 = MOSFET_IRLML6401TR
R1-R18 R28 R31 R32 R34 R36 R38-R53 R55-R59 R62 R63 R67-R73 R76-R86 R89 R100-R111 R113 R116 R119-R122 R124-R209 R211 R214-R223 R226-R233 R237-R245 R247-R267 R271-R291 R293 R295-R319 R321-R362 R365-R378 R381-R423 R425-R437 R461 R463-R477 R479-R544 R550-R554 R1381 R1383 R1647-R1649 R1652 R1653 R1667 R1668 R1678 R1679 R3832-R3836 R3842-R3844 R3849 R3852 R3858 R3861 R3864-R3867 R3870-R3882 = RESISTOR
R20 R87 R90-R99 R117 R118 R210 R212 R213 R292 R320 R1399 = RESISTOR: signal model: RESISTOR_RES0402_0-5_0E_0E
R29 R225 = RESISTOR: signal model: RESISTOR_RES0402_0-5_2.49K_1%_2.49K_1%
R74 R75 = RESISTOR-4TERM
R112 = RESISTOR: signal model: RESISTOR_RES0201_0-5_22E_1%_22E_1%
R114 = RESISTOR: signal model: RESISTOR_RES0201_0-5_0E_0E
R123 = RESISTOR: signal model: RESISTOR_RES0402_0-5_22E_1%_22E_1%
R439-R442 R451-R458 = RESISTOR: signal model: RESISTOR_RES0402_0-5_22E_22E
RA2-RA5 = RESARR_ISO4
SW1 SW5 SW14-SW16 = SW2_CHS-01TA
SW4 SW7 SW8 SW13 = SWTACT_CAS-120TA
SW6 = SW8_GDH04S04
SW9 = SWTACT_CAS-D20TA
SW10-SW12 = SW4_430182050816
TP1 TP2 TP5-TP8 TP10 TP13 TP15-TP21 TP23-TP63 TP66-TP86 = TESTPOINT
U1 = XAM263P4ASOKFZCZ_BGA324
U2 = SN74AHC1G02DBV_SOT23-5
U3 = TPS22965DSGT_WSON8
U4 = TPS2121RUXT_VQFNHR12
U5 = TPS61089_VQFN11
U7 = TPS6538600-Q1_HTSSOP48
U8 U20 U26 U30 U33 U44 U72 U73 = SN74CB3Q3257PWR_TSSOP16
U9 = TPS62903_VQFNHR9
U10 = TPS62177_WSON10
U12 U13 = INA226AIDGS_MSOP10
U14 = TPS62097RWKT_VQFNHR11
U15 = TLV71318PDQNR_X2SON4
U16 U23 = TPS22918DBVR_SOT23-6
U17 = TUSB320LAI_X2QFN12
U18 = W25N01GVZEIG_WSON8
U19 = IS25LX256_TFBGA24
U21 U22 U36 U39 U49 U79 = SN74LVC1G08DBVRE4_SOT23-5
U24 = TPD6E001RSE_UQFN10
U25 = TPD2E001DRLR_SOT-5_1
U27 = TMP411ADR_SOIC8
U28 = AT24HC04B-TH-B_TSSOP8
U29 = TCAN1043DQ1_SOIC14
U31 U58 = ISO7220XD_SOIC8
U32 U54 = ISO7221XD_SOIC8
U35 = DP83869HM_VQFN48
U41 = LMK1C1103_TSSOP8
U42 = OSC4_EQXP-HC33
U43 = SN74LVC1G07DBVR_SOT23-5
U45 = TLIN2029DQ1_SOIC8
U46 U56 = ISO1641B_SOIC8
U47 = TCA6408ARGTR_VQFN16
U48 = SN74AVC4T245RSV_UQFN16
U50 = SN74LVC1G17DCKR_SC70-5
U51 = TPS79601DRBR_SON8
U52 = TM4C1294NCPDTT3R_TQFP128
U53 = TPD4E004_SON6_0
U55 = LM4040B25IDCKR_SC70-5
U57 = ISO6760_SOIC16
U59 = TPIC2810D_SOIC16
U60 = TCA6424ARGJR_QFN32
U61-U65 U68 U69 = TPD4E001_SOT23-6
U66 = TLV75801P_WSON6
U67 = OPA4350EA_SSOP16
U70 U74 U75 = TMUX1136_USON10
U76 = SN74LVC3G07QDCURQ1_VSSOP8
U78 = SN74LVC1G11DCKR_SC70-6
U80 U82 U84 U85 U87-U89 = TS3DDR3812RUAR_WQFN42
U81 U90 = TMUX154EDGSR_VSSOP10
Y1 = CRY4_ABM8G
Y2 = CRY4_13

## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated)
BGA324_31-49_590X590_1-4
  round 0.406 smd: A1(-6.8,6.8) A2(-6,6.8) A3(-5.2,6.8) A4(-4.4,6.8) A5(-3.6,6.8) A6(-2.8,6.8) A7(-2,6.8) A8(-1.2,6.8) A9(-0.4,6.8) A10(0.4,6.8) A11(1.2,6.8) A12(2,6.8) A13(2.8,6.8) A14(3.6,6.8) A15(4.4,6.8) A16(5.2,6.8) A17(6,6.8) A18(6.8,6.8) B1(-6.8,6) B2(-6,6) B3(-5.2,6) B4(-4.4,6) B5(-3.6,6) B6(-2.8,6) B7(-2,6) B8(-1.2,6) B9(-0.4,6) B10(0.4,6) B11(1.2,6) B12(2,6) B13(2.8,6) B14(3.6,6) B15(4.4,6) B16(5.2,6) B17(6,6) B18(6.8,6) C1(-6.8,5.2) C2(-6,5.2) C3(-5.2,5.2) C4(-4.4,5.2) C5(-3.6,5.2) C6(-2.8,5.2) C7(-2,5.2) C8(-1.2,5.2) C9(-0.4,5.2) C10(0.4,5.2) C11(1.2,5.2) C12(2,5.2) C13(2.8,5.2) C14(3.6,5.2) C15(4.4,5.2) C16(5.2,5.2) C17(6,5.2) C18(6.8,5.2) D1(-6.8,4.4) D2(-6,4.4) D3(-5.2,4.4) D4(-4.4,4.4) D5(-3.6,4.4) D6(-2.8,4.4) D7(-2,4.4) D8(-1.2,4.4) D9(-0.4,4.4) D10(0.4,4.4) D11(1.2,4.4) D12(2,4.4) D13(2.8,4.4) D14(3.6,4.4) D15(4.4,4.4) D16(5.2,4.4) D17(6,4.4) D18(6.8,4.4) E1(-6.8,3.6) E2(-6,3.6) E3(-5.2,3.6) E4(-4.4,3.6) E5(-3.6,3.6) E6(-2.8,3.6) E7(-2,3.6) E8(-1.2,3.6) E9(-0.4,3.6) E10(0.4,3.6) E11(1.2,3.6) E12(2,3.6) E13(2.8,3.6) E14(3.6,3.6) E15(4.4,3.6) E16(5.2,3.6) E17(6,3.6) E18(6.8,3.6) F1(-6.8,2.8) F2(-6,2.8) F3(-5.2,2.8) F4(-4.4,2.8) F5(-3.6,2.8) F6(-2.8,2.8) F7(-2,2.8) F8(-1.2,2.8) F9(-0.4,2.8) F10(0.4,2.8) F11(1.2,2.8) F12(2,2.8) F13(2.8,2.8) F14(3.6,2.8) F15(4.4,2.8) F16(5.2,2.8) F17(6,2.8) F18(6.8,2.8) G1(-6.8,2) G2(-6,2) G3(-5.2,2) G4(-4.4,2) G5(-3.6,2) G6(-2.8,2) G7(-2,2) G8(-1.2,2) G9(-0.4,2) G10(0.4,2) G11(1.2,2) G12(2,2) G13(2.8,2) G14(3.6,2) G15(4.4,2) G16(5.2,2) G17(6,2) G18(6.8,2) H1(-6.8,1.2) H2(-6,1.2) H3(-5.2,1.2) H4(-4.4,1.2) H5(-3.6,1.2) H6(-2.8,1.2) H7(-2,1.2) H8(-1.2,1.2) H9(-0.4,1.2) H10(0.4,1.2) H11(1.2,1.2) H12(2,1.2) H13(2.8,1.2) H14(3.6,1.2) H15(4.4,1.2) H16(5.2,1.2) H17(6,1.2) H18(6.8,1.2) J1(-6.8,0.4) J2(-6,0.4) J3(-5.2,0.4) J4(-4.4,0.4) J5(-3.6,0.4) J6(-2.8,0.4) J7(-2,0.4) J8(-1.2,0.4) J9(-0.4,0.4) J10(0.4,0.4) J11(1.2,0.4) J12(2,0.4) J13(2.8,0.4) J14(3.6,0.4) J15(4.4,0.4) J16(5.2,0.4) J17(6,0.4) J18(6.8,0.4) K1(-6.8,-0.4) K2(-6,-0.4) K3(-5.2,-0.4) K4(-4.4,-0.4) K5(-3.6,-0.4) K6(-2.8,-0.4) K7(-2,-0.4) K8(-1.2,-0.4) K9(-0.4,-0.4) K10(0.4,-0.4) K11(1.2,-0.4) K12(2,-0.4) K13(2.8,-0.4) K14(3.6,-0.4) K15(4.4,-0.4) K16(5.2,-0.4) K17(6,-0.4) K18(6.8,-0.4) L1(-6.8,-1.2) L2(-6,-1.2) L3(-5.2,-1.2) L4(-4.4,-1.2) L5(-3.6,-1.2) L6(-2.8,-1.2) L7(-2,-1.2) L8(-1.2,-1.2) L9(-0.4,-1.2) L10(0.4,-1.2) L11(1.2,-1.2) L12(2,-1.2) L13(2.8,-1.2) L14(3.6,-1.2) L15(4.4,-1.2) L16(5.2,-1.2) L17(6,-1.2) L18(6.8,-1.2) M1(-6.8,-2) M2(-6,-2) M3(-5.2,-2) M4(-4.4,-2) M5(-3.6,-2) M6(-2.8,-2) M7(-2,-2) M8(-1.2,-2) M9(-0.4,-2) M10(0.4,-2) M11(1.2,-2) M12(2,-2) M13(2.8,-2) M14(3.6,-2) M15(4.4,-2) M16(5.2,-2) M17(6,-2) M18(6.8,-2) N1(-6.8,-2.8) N2(-6,-2.8) N3(-5.2,-2.8) N4(-4.4,-2.8) N5(-3.6,-2.8) N6(-2.8,-2.8) N7(-2,-2.8) N8(-1.2,-2.8) N9(-0.4,-2.8) N10(0.4,-2.8) N11(1.2,-2.8) N12(2,-2.8) N13(2.8,-2.8) N14(3.6,-2.8) N15(4.4,-2.8) N16(5.2,-2.8) N17(6,-2.8) N18(6.8,-2.8) P1(-6.8,-3.6) P2(-6,-3.6) P3(-5.2,-3.6) P4(-4.4,-3.6) P5(-3.6,-3.6) P6(-2.8,-3.6) P7(-2,-3.6) P8(-1.2,-3.6) P9(-0.4,-3.6) P10(0.4,-3.6) P11(1.2,-3.6) P12(2,-3.6) P13(2.8,-3.6) P14(3.6,-3.6) P15(4.4,-3.6) P16(5.2,-3.6) P17(6,-3.6) P18(6.8,-3.6) R1(-6.8,-4.4) R2(-6,-4.4) R3(-5.2,-4.4) R4(-4.4,-4.4) R5(-3.6,-4.4) R6(-2.8,-4.4) R7(-2,-4.4) R8(-1.2,-4.4) R9(-0.4,-4.4) R10(0.4,-4.4) R11(1.2,-4.4) R12(2,-4.4) R13(2.8,-4.4) R14(3.6,-4.4) R15(4.4,-4.4) R16(5.2,-4.4) R17(6,-4.4) R18(6.8,-4.4) T1(-6.8,-5.2) T2(-6,-5.2) T3(-5.2,-5.2) T4(-4.4,-5.2) T5(-3.6,-5.2) T6(-2.8,-5.2) T7(-2,-5.2) T8(-1.2,-5.2) T9(-0.4,-5.2) T10(0.4,-5.2) T11(1.2,-5.2) T12(2,-5.2) T13(2.8,-5.2) T14(3.6,-5.2) T15(4.4,-5.2) T16(5.2,-5.2) T17(6,-5.2) T18(6.8,-5.2) U1(-6.8,-6) U2(-6,-6) U3(-5.2,-6) U4(-4.4,-6) U5(-3.6,-6) U6(-2.8,-6) U7(-2,-6) U8(-1.2,-6) U9(-0.4,-6) U10(0.4,-6) U11(1.2,-6) U12(2,-6) U13(2.8,-6) U14(3.6,-6) U15(4.4,-6) U16(5.2,-6) U17(6,-6) U18(6.8,-6) V1(-6.8,-6.8) V2(-6,-6.8) V3(-5.2,-6.8) V4(-4.4,-6.8) V5(-3.6,-6.8) V6(-2.8,-6.8) V7(-2,-6.8) V8(-1.2,-6.8) V9(-0.4,-6.8) V10(0.4,-6.8) V11(1.2,-6.8) V12(2,-6.8) V13(2.8,-6.8) V14(3.6,-6.8) V15(4.4,-6.8) V16(5.2,-6.8) V17(6,-6.8) V18(6.8,-6.8)
CAP0201_0-5
  rect 0.356x0.33 smd: 1(-0.28,0) 2(0.28,0)
CAP0402_0-75
  rect 0.559x0.635 smd: 1(-0.49,0) 2(0.49,0)
CAP0603_1
  rect 0.94x1.016 smd: 1(-0.8,0) 2(0.8,0)
CAP0805_1-5
  rect 1.143x1.448 smd: 1(-0.9,0) 2(0.9,0)
CAP1206_1-75
  rect 1.143x1.803 smd: 1(-1.5,0) 2(1.5,0)
CAP1206_2
  rect 1.143x1.803 smd: 1(-1.5,0) 2(1.5,0)
CAP1812_1-25
  rect 1.6x3.505 smd: 1(-2,0) 2(2,0)
CON_BTOB2X24_DF40GB-48DP_P_S_S_1-3
  rect 0.229x0.66 smd: 1(-4.6,-1.355) 2(-4.6,1.355) 3(-4.2,-1.355) 4(-4.2,1.355) 5(-3.8,-1.355) 6(-3.8,1.355) 7(-3.4,-1.355) 8(-3.4,1.355) 9(-3,-1.355) 10(-3,1.355) 11(-2.6,-1.355) 12(-2.6,1.355) 13(-2.2,-1.355) 14(-2.2,1.355) 15(-1.8,-1.355) 16(-1.8,1.355) 17(-1.4,-1.355) 18(-1.4,1.355) 19(-1,-1.355) 20(-1,1.355) 21(-0.6,-1.355) 22(-0.6,1.355) 23(-0.2,-1.355) 24(-0.2,1.355) 25(0.2,-1.355) 26(0.2,1.355) 27(0.6,-1.355) 28(0.6,1.355) 29(1,-1.355) 30(1,1.355) 31(1.4,-1.355) 32(1.4,1.355) 33(1.8,-1.355) 34(1.8,1.355) 35(2.2,-1.355) 36(2.2,1.355) 37(2.6,-1.355) 38(2.6,1.355) 39(3,-1.355) 40(3,1.355) 41(3.4,-1.355) 42(3.4,1.355) 43(3.8,-1.355) 44(3.8,1.355) 45(4.2,-1.355) 46(4.2,1.355) 47(4.6,-1.355) 48(4.6,1.355)
  rect 0.356x0.711 smd: SH1(-5.135,-0.86) SH2(-5.135,0.86) SH3(5.135,-0.86) SH4(5.135,0.86)
CON_EDGE180_HSEC8-180_FING_P_R_S
  rect 0.559x2.794 smd: 1(-47.299,0) 2(-47.299,0) 3(-46.499,0) 4(-46.499,0) 5(-45.699,0) 6(-45.699,0) 7(-44.899,0) 8(-44.899,0) 9(-44.099,0) 10(-44.099,0) 11(-43.299,0) 12(-43.299,0) 13(-42.499,0) 14(-42.499,0) 15(-41.699,0) 16(-41.699,0) 17(-40.899,0) 18(-40.899,0) 19(-40.099,0) 20(-40.099,0) 21(-39.299,0) 22(-39.299,0) 23(-38.499,0) 24(-38.499,0) 25(-37.699,0) 26(-37.699,0) 27(-36.899,0) 28(-36.899,0) 29(-36.099,0) 30(-36.099,0) 31(-35.299,0) 32(-35.299,0) 33(-34.499,0) 34(-34.499,0) 35(-33.699,0) 36(-33.699,0) 37(-32.899,0) 38(-32.899,0) 39(-32.099,0) 40(-32.099,0) 41(-31.299,0) 42(-31.299,0) 43(-30.499,0) 44(-30.499,0) 45(-29.699,0) 46(-29.699,0) 47(-28.899,0) 48(-28.899,0) 49(-28.099,0) 50(-28.099,0) 51(-27.299,0) 52(-27.299,0) 53(-26.499,0) 54(-26.499,0) 55(-25.699,0) 56(-25.699,0) 57(-21.699,0) 58(-21.699,0) 59(-20.899,0) 60(-20.899,0) 61(-20.099,0) 62(-20.099,0) 63(-19.299,0) 64(-19.299,0) 65(-18.499,0) 66(-18.499,0) 67(-17.699,0) 68(-17.699,0) 69(-16.899,0) 70(-16.899,0) 71(-16.099,0) 72(-16.099,0) 73(-15.299,0) 74(-15.299,0) 75(-14.499,0) 76(-14.499,0) 77(-13.699,0) 78(-13.699,0) 79(-12.899,0) 80(-12.899,0) 81(-12.099,0) 82(-12.099,0) 83(-11.299,0) 84(-11.299,0) 85(-10.499,0) 86(-10.499,0) 87(-9.699,0) 88(-9.699,0) 89(-8.899,0) 90(-8.899,0) 91(-8.099,0) 92(-8.099,0) 93(-7.299,0) 94(-7.299,0) 95(-6.499,0) 96(-6.499,0) 97(-5.699,0) 98(-5.699,0) 99(-4.899,0) 100(-4.899,0) 101(-4.099,0) 102(-4.099,0) 103(-3.299,0) 104(-3.299,0) 105(-2.499,0) 106(-2.499,0) 107(-1.699,0) 108(-1.699,0) 109(-0.899,0) 110(-0.899,0) 111(-0.099,0) 112(-0.099,0) 113(0.701,0) 114(0.701,0) 115(1.501,0) 116(1.501,0) 117(2.301,0) 118(2.301,0) 119(3.101,0) 120(3.101,0) 121(24.099,0) 122(24.099,0) 123(24.899,0) 124(24.899,0) 125(25.699,0) 126(25.699,0) 127(26.499,0) 128(26.499,0) 129(27.299,0) 130(27.299,0) 131(28.099,0) 132(28.099,0) 133(28.899,0) 134(28.899,0) 135(29.699,0) 136(29.699,0) 137(30.499,0) 138(30.499,0) 139(31.299,0) 140(31.299,0) 141(32.099,0) 142(32.099,0) 143(32.899,0) 144(32.899,0) 145(33.699,0) 146(33.699,0) 147(34.499,0) 148(34.499,0) 149(35.299,0) 150(35.299,0) 151(36.099,0) 152(36.099,0) 153(36.899,0) 154(36.899,0) 155(37.699,0) 156(37.699,0) 157(38.499,0) 158(38.499,0) 159(39.299,0) 160(39.299,0) 161(40.099,0) 162(40.099,0) 163(40.899,0) 164(40.899,0) 165(41.699,0) 166(41.699,0) 167(42.499,0) 168(42.499,0) 169(43.299,0) 170(43.299,0) 171(44.099,0) 172(44.099,0) 173(44.899,0) 174(44.899,0) 175(45.699,0) 176(45.699,0) 177(46.499,0) 178(46.499,0) 179(47.299,0) 180(47.299,0)
CON_FLEX40X1_FH12A_S_R_S
  rect 0.33x1.397 smd: 1(-9.75,3.575) 2(-9.25,3.575) 3(-8.75,3.575) 4(-8.25,3.575) 5(-7.75,3.575) 6(-7.25,3.575) 7(-6.75,3.575) 8(-6.25,3.575) 9(-5.75,3.575) 10(-5.25,3.575) 11(-4.75,3.575) 12(-4.25,3.575) 13(-3.75,3.575) 14(-3.25,3.575) 15(-2.75,3.575) 16(-2.25,3.575) 17(-1.75,3.575) 18(-1.25,3.575) 19(-0.75,3.575) 20(-0.25,3.575) 21(0.25,3.575) 22(0.75,3.575) 23(1.25,3.575) 24(1.75,3.575) 25(2.25,3.575) 26(2.75,3.575) 27(3.25,3.575) 28(3.75,3.575) 29(4.25,3.575) 30(4.75,3.575) 31(5.25,3.575) 32(5.75,3.575) 33(6.25,3.575) 34(6.75,3.575) 35(7.25,3.575) 36(7.75,3.575) 37(8.25,3.575) 38(8.75,3.575) 39(9.25,3.575) 40(9.75,3.575)
  rect 1.803x2.311 smd: 41(-11.65,0.325) 42(11.65,0.325)
CON_RJ45-14_LPJG16314A4NL_S_R_T_13-6
  round 3.073 hole 3.2 unplated: (0,-8.89) (11.43,-8.89)
  rect 1.6x1.6 hole 0.914: 1(0,0)
  round 1.6 hole 0.914: 2(1.27,-2.54) 3(2.54,0) 4(3.81,-2.54) 5(5.08,0) 6(6.35,-2.54) 7(7.62,0) 8(8.89,-2.54) 9(10.16,0) 10(11.43,-2.54)
  round 1.702 hole 1.016: 11(12.44,-11.43) 12(12.44,-13.462) 13(-1.01,-11.43) 14(-1.01,-13.462)
  round 2.362 hole 1.676: 15(-2.032,-5.842) 16(13.462,-5.842)
CON_SD10_DM3BT-DSF-PEJS_S_R_S_2-4
  rect 0.711x1.422 smd: 1(-2.715,7.801) 2(-1.615,7.801) 3(-0.515,7.801) 4(0.585,7.801) 5(1.685,7.801) 6(2.785,7.801) 7(3.885,7.801) 8(4.985,7.801)
  rect 0.711x1.219 smd: 9(5.935,7.901)
  rect 1.016x1.422 smd: 10(-4.615,7.801)
  rect 1.219x1.219 smd: 11(6.785,3.601)
  rect 1.219x0.813 smd: 12(6.785,-2.599)
  rect 1.219x3.2 smd: 13(6.785,-6.199)
  rect 2.007x1.905 smd: 14(-6.265,-7.199)
CON_USBB5_2013499-1_S_R_S_3
  rect 0.457x1.397 smd: 1(-1.3,2.504) 2(-0.65,2.504) 3(0,2.504) 4(0.65,2.504) 5(1.3,2.504)
  rect 1.6x1.448 smd: 6(-3.2,2.279) 7(3.2,2.279)
  oval 1.219x2.438 hole 0.711x1.93: 8(-3.255,-0.171) 11(3.255,-0.171)
  rect 1.905x1.956 smd: 9(-1.2,-0.171) 10(1.2,-0.171)
CON_USBC24_2012670_S_R_S_3-9
  rect 0.305x0.762 smd: A1(-3,4.056) A2(-2.5,4.056) A3(-2,4.056) A4(-1.5,4.056) A5(-1,4.056) A6(-0.5,4.056) A7(0.5,4.056) A8(1,4.056) A9(1.5,4.056) A10(2,4.056) A11(2.5,4.056) A12(3,4.056) B2(2.25,2.356) B3(1.75,2.356) B4(1.25,2.356) B5(0.75,2.356) B6(0.25,2.356) B7(-0.25,2.356) B8(-0.75,2.356) B9(-1.25,2.356) B10(-1.75,2.356) B11(-2.25,2.356)
  rect 0.94x0.762 smd: B1(3.05,2.356) B12(-3.05,2.356)
  oval 1.194x2.21 hole 0.61x1.575: SH1(-4.32,3.246) SH2(4.32,3.246)
  oval 1.194x3.708 hole 0.61x2.083: SH3(4.62,-2.114) SH4(-4.62,-2.114)
DIO_DFN0201_0-4
  rect 0.229x0.381 smd: 1(-0.22,0) 2(0.22,0)
DIO_SOD123_1-4
  rect 1.016x0.813 smd: 1(-1.8,0) 2(1.8,0)
DIO_SOD523F_0-7
  rect 0.737x0.406 smd: 1(-0.74,0) 2(0.74,0)
EMIFIL_BLM18R_0603
  rect 0.94x1.194 smd: 1(-0.825,0) 2(0.825,0)
EMIFIL_BLM18R_0603_1
  rect 0.787x0.889 smd: 1(-0.65,0) 2(0.65,0)
EMIFIL_BLM18S_0603_0-7
  rect 0.991x0.991 smd: 1(-0.75,0) 2(0.75,0)
HDR_1X3_100_S_T
  rect 1.803x1.803 hole 1.118: 1(0,0)
  round 1.803 hole 1.118: 2(-2.54,0) 3(-5.08,0)
HDR_2X1_100_S_T
  rect 1.702x1.702 hole 1.016: 1(0,0)
  round 1.702 hole 1.016: 2(-2.54,0)
HDR_2X1_100_S_T_10-8
  rect 1.702x1.702 hole 1.016: 1(0,0)
  round 1.702 hole 1.016: 2(-2.54,0)
HDR_2X2_5-146256-2_S_T_8-3
  rect 1.6x1.6 hole 0.914: 1(0,0)
  round 1.6 hole 0.914: 2(0,2.54) 3(2.54,0) 4(2.54,2.54)
HDR_2X5_61301021121_S_T_8-6
  rect 1.803x1.803 hole 1.118: 1(0,0)
  round 1.803 hole 1.118: 2(0,2.54) 3(2.54,0) 4(2.54,2.54) 5(5.08,0) 6(5.08,2.54) 7(7.62,0) 8(7.62,2.54) 9(10.16,0) 10(10.16,2.54)
HTSSOP48_19-68_500X245_1-2
  rect 1.499x0.305 smd: 1(-3.75,5.75) 2(-3.75,5.25) 3(-3.75,4.75) 4(-3.75,4.25) 5(-3.75,3.75) 6(-3.75,3.25) 7(-3.75,2.75) 8(-3.75,2.25) 9(-3.75,1.75) 10(-3.75,1.25) 11(-3.75,0.75) 12(-3.75,0.25) 13(-3.75,-0.25) 14(-3.75,-0.75) 15(-3.75,-1.25) 16(-3.75,-1.75) 17(-3.75,-2.25) 18(-3.75,-2.75) 19(-3.75,-3.25) 20(-3.75,-3.75) 21(-3.75,-4.25) 22(-3.75,-4.75) 23(-3.75,-5.25) 24(-3.75,-5.75) 25(3.75,-5.75) 26(3.75,-5.25) 27(3.75,-4.75) 28(3.75,-4.25) 29(3.75,-3.75) 30(3.75,-3.25) 31(3.75,-2.75) 32(3.75,-2.25) 33(3.75,-1.75) 34(3.75,-1.25) 35(3.75,-0.75) 36(3.75,-0.25) 37(3.75,0.25) 38(3.75,0.75) 39(3.75,1.25) 40(3.75,1.75) 41(3.75,2.25) 42(3.75,2.75) 43(3.75,3.25) 44(3.75,3.75) 45(3.75,4.25) 46(3.75,4.75) 47(3.75,5.25) 48(3.75,5.75)
  rect 5.105x12.497 smd: 49(0,0)
IND1008
  rect 1.397x2.337 smd: 1(-1.2,0) 2(1.2,0)
IND_74405042100_170X170_SMD_2
  rect 1.194x3.302 smd: 1(-1.55,0) 2(1.55,0)
IND_IHLP2020B_230X215_SMD
  rect 1.905x2.794 smd: 1(-2.037,0) 2(2.037,0)
IND_XAL4020_170X170_SMD_3-1
  rect 0.991x3.404 smd: 1(-1.185,0) 2(1.185,0)
LED_150040GS73220_40X20_SMD_0-4
  rect 0.406x0.457 smd: 1(-0.5,0) 2(0.5,0)
LED_150080VS75000_80X50_SMD_0-8
  rect 1.092x1.194 smd: 1(-1.05,0) 2(1.05,0)
MSOP10_19-68_120X120_1-1
  rect 1.448x0.305 smd: 1(-2.2,1) 2(-2.2,0.5) 3(-2.2,0) 4(-2.2,-0.5) 5(-2.2,-1) 6(2.2,-1) 7(2.2,-0.5) 8(2.2,0) 9(2.2,0.5) 10(2.2,1)
OSC4_ASEK_130X100_SMD_1-2
  rect 1.397x0.991 smd: 1(-1.1,-0.8) 2(1.1,-0.8) 3(1.1,0.8) 4(-1.1,0.8)
QFN16_19-68_120X120_1_EP1-6
  rect 0.711x0.305 smd: 1(-1.45,0.75) 2(-1.45,0.25) 3(-1.45,-0.25) 4(-1.45,-0.75) 9(1.45,-0.75) 10(1.45,-0.25) 11(1.45,0.25) 12(1.45,0.75)
  rect 0.305x0.711 smd: 5(-0.75,-1.45) 6(-0.25,-1.45) 7(0.25,-1.45) 8(0.75,-1.45) 13(0.75,1.45) 14(0.25,1.45) 15(-0.25,1.45) 16(-0.75,1.45)
  rect 1.6x1.6 smd: 17(0,0)
QFN32_19-68_200X200
  rect 0.94x0.305 smd: 1(-2.55,1.75) 2(-2.55,1.25) 3(-2.55,0.75) 4(-2.55,0.25) 5(-2.55,-0.25) 6(-2.55,-0.75) 7(-2.55,-1.25) 8(-2.55,-1.75) 17(2.55,-1.75) 18(2.55,-1.25) 19(2.55,-0.75) 20(2.55,-0.25) 21(2.55,0.25) 22(2.55,0.75) 23(2.55,1.25) 24(2.55,1.75)
  rect 0.305x0.94 smd: 9(-1.75,-2.55) 10(-1.25,-2.55) 11(-0.75,-2.55) 12(-0.25,-2.55) 13(0.25,-2.55) 14(0.75,-2.55) 15(1.25,-2.55) 16(1.75,-2.55) 25(1.75,2.55) 26(1.25,2.55) 27(0.75,2.55) 28(0.25,2.55) 29(-0.25,2.55) 30(-0.75,2.55) 31(-1.25,2.55) 32(-1.75,2.55)
  rect 3.556x3.556 smd: 33(0,0)
QFN48_19-68_280X280_1_EP4-2
  rect 0.838x0.305 smd: 1(-3.5,2.75) 2(-3.5,2.25) 3(-3.5,1.75) 4(-3.5,1.25) 5(-3.5,0.75) 6(-3.5,0.25) 7(-3.5,-0.25) 8(-3.5,-0.75) 9(-3.5,-1.25) 10(-3.5,-1.75) 11(-3.5,-2.25) 12(-3.5,-2.75) 25(3.5,-2.75) 26(3.5,-2.25) 27(3.5,-1.75) 28(3.5,-1.25) 29(3.5,-0.75) 30(3.5,-0.25) 31(3.5,0.25) 32(3.5,0.75) 33(3.5,1.25) 34(3.5,1.75) 35(3.5,2.25) 36(3.5,2.75)
  rect 0.305x0.838 smd: 13(-2.75,-3.5) 14(-2.25,-3.5) 15(-1.75,-3.5) 16(-1.25,-3.5) 17(-0.75,-3.5) 18(-0.25,-3.5) 19(0.25,-3.5) 20(0.75,-3.5) 21(1.25,-3.5) 22(1.75,-3.5) 23(2.25,-3.5) 24(2.75,-3.5) 37(2.75,3.5) 38(2.25,3.5) 39(1.75,3.5) 40(1.25,3.5) 41(0.75,3.5) 42(0.25,3.5) 43(-0.25,3.5) 44(-0.75,3.5) 45(-1.25,3.5) 46(-1.75,3.5) 47(-2.25,3.5) 48(-2.75,3.5)
  rect 4.191x4.191 smd: 49(0,0)
QSOP16_25_200X160_1-8
  rect 1.549x0.406 smd: 1(-2.7,2.223) 2(-2.7,1.587) 3(-2.7,0.953) 4(-2.7,0.318) 5(-2.7,-0.318) 6(-2.7,-0.953) 7(-2.7,-1.587) 8(-2.7,-2.223) 9(2.7,-2.223) 10(2.7,-1.587) 11(2.7,-0.953) 12(2.7,-0.318) 13(2.7,0.318) 14(2.7,0.953) 15(2.7,1.587) 16(2.7,2.223)
RES0201_0-5
  rect 0.457x0.432 smd: 1(-0.33,0) 2(0.33,0)
RES0402_0-5
  rect 0.559x0.635 smd: 1(-0.49,0) 2(0.49,0)
RES0402_0-5#2
  rect 0.508x0.508 smd: 1(-0.42,0) 2(0.42,0)
RES0805_0-75
  rect 0.762x1.346 smd: 1(-0.9,0) 2(0.9,0)
RES_FC4L16_0306-4_0-7
  rect 0.483x0.406 smd: 1(-0.362,0.75) 4(0.362,0.75)
  rect 0.483x1.194 smd: 2(-0.362,-0.35) 3(0.362,-0.35)
RESA_EXB28V_0402-4_0-5
  rect 0.533x0.508 smd: 1(-0.887,-0.45) 4(0.887,-0.45) 5(0.887,0.45) 8(-0.887,0.45)
  rect 0.254x0.508 smd: 2(-0.25,-0.45) 3(0.25,-0.45) 6(0.25,0.45) 7(-0.25,0.45)
SC70-5
  rect 0.762x0.406 smd: 1(-1,0.65) 2(-1,0) 3(-1,-0.65) 4(1,-0.65) 5(1,0.65)
SC70-5_1-1
  rect 0.762x0.406 smd: 1(-1,0.65) 2(-1,0) 3(-1,-0.65) 4(1,-0.65) 5(1,0.65)
SC70-6
  rect 0.762x0.406 smd: 1(-1,0.65) 2(-1,0) 3(-1,-0.65) 4(1,-0.65) 5(1,0) 6(1,0.65)
SOIC8
  rect 1.346x0.559 smd: 1(-2.6,1.905) 2(-2.6,0.635) 3(-2.6,-0.635) 4(-2.6,-1.905) 5(2.6,-1.905) 6(2.6,-0.635) 7(2.6,0.635) 8(2.6,1.905)
SOIC8_1-8
  rect 1.549x0.61 smd: 1(-2.7,1.905) 2(-2.7,0.635) 3(-2.7,-0.635) 4(-2.7,-1.905) 5(2.7,-1.905) 6(2.7,-0.635) 7(2.7,0.635) 8(2.7,1.905)
SOIC16_1-8
  rect 1.549x0.61 smd: 1(-2.7,4.445) 2(-2.7,3.175) 3(-2.7,1.905) 4(-2.7,0.635) 5(-2.7,-0.635) 6(-2.7,-1.905) 7(-2.7,-3.175) 8(-2.7,-4.445) 9(2.7,-4.445) 10(2.7,-3.175) 11(2.7,-1.905) 12(2.7,-0.635) 13(2.7,0.635) 14(2.7,1.905) 15(2.7,3.175) 16(2.7,4.445)
SOIC16_W
  rect 1.753x0.61 smd: 1(-4.6,4.445) 2(-4.6,3.175) 3(-4.6,1.905) 4(-4.6,0.635) 5(-4.6,-0.635) 6(-4.6,-1.905) 7(-4.6,-3.175) 8(-4.6,-4.445) 9(4.6,-4.445) 10(4.6,-3.175) 11(4.6,-1.905) 12(4.6,-0.635) 13(4.6,0.635) 14(4.6,1.905) 15(4.6,3.175) 16(4.6,4.445)
SON6_19-68_40X60_PB_0-6
  rect 0.356x0.305 smd: 1(-0.3,0.5) 2(-0.3,0) 3(-0.3,-0.5) 4(0.3,-0.5) 5(0.3,0) 6(0.3,0.5)
SON6_25-59_85X85_0-8
  rect 0.508x0.356 smd: 1(-1,0.65) 2(-1,0) 3(-1,-0.65) 4(1,-0.65) 5(1,0) 6(1,0.65)
  rect 1.092x1.702 smd: 7(0,0)
SON8_25-59_130X130_1
  rect 0.762x0.356 smd: 1(-1.45,0.975) 2(-1.45,0.325) 3(-1.45,-0.325) 4(-1.45,-0.975) 5(1.45,-0.975) 6(1.45,-0.325) 7(1.45,0.325) 8(1.45,0.975)
  rect 1.753x2.515 smd: 9(0,0)
SOT23-5
  rect 1.092x0.61 smd: 1(-1.3,0.95) 2(-1.3,0) 3(-1.3,-0.95) 4(1.3,-0.95) 5(1.3,0.95)
SOT23-6
  rect 0.889x0.559 smd: 1(-1.2,0.95) 2(-1.2,0) 3(-1.2,-0.95) 4(1.2,-0.95) 5(1.2,0) 6(1.2,0.95)
SOT23-14_1-1
  rect 1.041x0.305 smd: 1(-1.5,1.5) 2(-1.5,1) 3(-1.5,0.5) 4(-1.5,0) 5(-1.5,-0.5) 6(-1.5,-1) 7(-1.5,-1.5) 8(1.5,-1.5) 9(1.5,-1) 10(1.5,-0.5) 11(1.5,0) 12(1.5,0.5) 13(1.5,1) 14(1.5,1.5)
SOT23-123_1-2
  rect 1.016x0.61 smd: 1(-1.15,0.95) 2(-1.15,-0.95) 3(1.15,0)
SOT553-5_0-6
  rect 0.559x0.229 smd: 1(-0.69,0.5) 2(-0.69,0) 3(-0.69,-0.5) 4(0.69,-0.5) 5(0.69,0.5)
SW3_CAS-120TA_215X100_SMD
  rect 1.6x1.016 smd: 1(-1.75,-1.15) 2(0,1.15) 3(1.75,-1.15)
SW4_430182050816_240X240_SMD_5-2
  rect 1.549x1.295 smd: 1(-3.975,2.25) 2(-3.975,-2.25) 3(3.975,2.25) 4(3.975,-2.25)
SW6_CAS-D20A_210X150_SMD
  rect 1.6x1.016 smd: 1(-1.75,-1.85) 2(0,-1.85) 3(1.75,-1.85) 4(-1.75,1.85) 5(0,1.85) 6(1.75,1.85)
SW8_416131160804_260X230_SMD_2-7
  rect 0.762x1.27 smd: 1(-1.905,-3.81) 2(-0.635,-3.81) 3(0.635,-3.81) 4(1.905,-3.81) 5(1.905,3.81) 6(0.635,3.81) 7(-0.635,3.81) 8(-1.905,3.81)
SW_TDA01H0S_240X90_SMD_2-3
  rect 1.27x0.762 smd: 1(-3.81,0) 2(3.81,0)
TO_SOT23-123
  rect 1.016x1.397 smd: 1(-0.95,-1.1) 2(0.95,-1.1) 3(0,1.1)
TO_SOT23-123#2
  rect 0.838x0.61 smd: 1(-1.05,0.95) 2(-1.05,-0.95) 3(1.05,0)
TP20_SMD
  round 0.457 smd: 1(0,0)
TP30_SMD
  round 0.762 smd: 1(0,0)
TP40_SMD
  round 1.016 smd: 1(0,0)
TP_40X65
  round 1.651 hole 1.016: 1(0,0)
TPBGA24_39-37_240X320_1-2
  round 0.356 smd: A2(-1,2) A3(0,2) A4(1,2) A5(2,2) B1(-2,1) B2(-1,1) B3(0,1) B4(1,1) B5(2,1) C1(-2,0) C2(-1,0) C3(0,0) C4(1,0) C5(2,0) D1(-2,-1) D2(-1,-1) D3(0,-1) D4(1,-1) D5(2,-1) E1(-2,-2) E2(-1,-2) E3(0,-2) E4(1,-2) E5(2,-2)
TQFN42_19-68_140X360_0-8
  rect 0.813x0.305 smd: 1(-1.7,4) 2(-1.7,3.5) 3(-1.7,3) 4(-1.7,2.5) 5(-1.7,2) 6(-1.7,1.5) 7(-1.7,1) 8(-1.7,0.5) 9(-1.7,0) 10(-1.7,-0.5) 11(-1.7,-1) 12(-1.7,-1.5) 13(-1.7,-2) 14(-1.7,-2.5) 15(-1.7,-3) 16(-1.7,-3.5) 17(-1.7,-4) 22(1.7,-4) 23(1.7,-3.5) 24(1.7,-3) 25(1.7,-2.5) 26(1.7,-2) 27(1.7,-1.5) 28(1.7,-1) 29(1.7,-0.5) 30(1.7,0) 31(1.7,0.5) 32(1.7,1) 33(1.7,1.5) 34(1.7,2) 35(1.7,2.5) 36(1.7,3) 37(1.7,3.5) 38(1.7,4)
  rect 0.305x0.813 smd: 18(-0.75,-4.45) 19(-0.25,-4.45) 20(0.25,-4.45) 21(0.75,-4.45) 39(0.75,4.45) 40(0.25,4.45) 41(-0.25,4.45) 42(-0.75,4.45)
  rect 2.159x7.645 smd: 43(0,0)
TQFP128_15-74_550X550_1-2
  rect 1.499x0.203 smd: 1(-7.7,6.2) 2(-7.7,5.8) 3(-7.7,5.4) 4(-7.7,5) 5(-7.7,4.6) 6(-7.7,4.2) 7(-7.7,3.8) 8(-7.7,3.4) 9(-7.7,3) 10(-7.7,2.6) 11(-7.7,2.2) 12(-7.7,1.8) 13(-7.7,1.4) 14(-7.7,1) 15(-7.7,0.6) 16(-7.7,0.2) 17(-7.7,-0.2) 18(-7.7,-0.6) 19(-7.7,-1) 20(-7.7,-1.4) 21(-7.7,-1.8) 22(-7.7,-2.2) 23(-7.7,-2.6) 24(-7.7,-3) 25(-7.7,-3.4) 26(-7.7,-3.8) 27(-7.7,-4.2) 28(-7.7,-4.6) 29(-7.7,-5) 30(-7.7,-5.4) 31(-7.7,-5.8) 32(-7.7,-6.2) 65(7.7,-6.2) 66(7.7,-5.8) 67(7.7,-5.4) 68(7.7,-5) 69(7.7,-4.6) 70(7.7,-4.2) 71(7.7,-3.8) 72(7.7,-3.4) 73(7.7,-3) 74(7.7,-2.6) 75(7.7,-2.2) 76(7.7,-1.8) 77(7.7,-1.4) 78(7.7,-1) 79(7.7,-0.6) 80(7.7,-0.2) 81(7.7,0.2) 82(7.7,0.6) 83(7.7,1) 84(7.7,1.4) 85(7.7,1.8) 86(7.7,2.2) 87(7.7,2.6) 88(7.7,3) 89(7.7,3.4) 90(7.7,3.8) 91(7.7,4.2) 92(7.7,4.6) 93(7.7,5) 94(7.7,5.4) 95(7.7,5.8) 96(7.7,6.2)
  rect 0.203x1.499 smd: 33(-6.2,-7.7) 34(-5.8,-7.7) 35(-5.4,-7.7) 36(-5,-7.7) 37(-4.6,-7.7) 38(-4.2,-7.7) 39(-3.8,-7.7) 40(-3.4,-7.7) 41(-3,-7.7) 42(-2.6,-7.7) 43(-2.2,-7.7) 44(-1.8,-7.7) 45(-1.4,-7.7) 46(-1,-7.7) 47(-0.6,-7.7) 48(-0.2,-7.7) 49(0.2,-7.7) 50(0.6,-7.7) 51(1,-7.7) 52(1.4,-7.7) 53(1.8,-7.7) 54(2.2,-7.7) 55(2.6,-7.7) 56(3,-7.7) 57(3.4,-7.7) 58(3.8,-7.7) 59(4.2,-7.7) 60(4.6,-7.7) 61(5,-7.7) 62(5.4,-7.7) 63(5.8,-7.7) 64(6.2,-7.7) 97(6.2,7.7) 98(5.8,7.7) 99(5.4,7.7) 100(5,7.7) 101(4.6,7.7) 102(4.2,7.7) 103(3.8,7.7) 104(3.4,7.7) 105(3,7.7) 106(2.6,7.7) 107(2.2,7.7) 108(1.8,7.7) 109(1.4,7.7) 110(1,7.7) 111(0.6,7.7) 112(0.2,7.7) 113(-0.2,7.7) 114(-0.6,7.7) 115(-1,7.7) 116(-1.4,7.7) 117(-1.8,7.7) 118(-2.2,7.7) 119(-2.6,7.7) 120(-3,7.7) 121(-3.4,7.7) 122(-3.8,7.7) 123(-4.2,7.7) 124(-4.6,7.7) 125(-5,7.7) 126(-5.4,7.7) 127(-5.8,7.7) 128(-6.2,7.7)
TSSOP8_25-59_125X180_1-2
  rect 1.499x0.457 smd: 1(-2.9,0.975) 2(-2.9,0.325) 3(-2.9,-0.325) 4(-2.9,-0.975) 5(2.9,-0.975) 6(2.9,-0.325) 7(2.9,0.325) 8(2.9,0.975)
TSSOP16_25-59_205X180
  rect 1.6x0.356 smd: 1(-2.8,2.275) 2(-2.8,1.625) 3(-2.8,0.975) 4(-2.8,0.325) 5(-2.8,-0.325) 6(-2.8,-0.975) 7(-2.8,-1.625) 8(-2.8,-2.275) 9(2.8,-2.275) 10(2.8,-1.625) 11(2.8,-0.975) 12(2.8,-0.325) 13(2.8,0.325) 14(2.8,0.975) 15(2.8,1.625) 16(2.8,2.275)
unnamed
  round 2.616 hole 2.743 unplated: (0,0)
unnamed#2
  round 0.686 hole 0.813 unplated: (-1.27,1.254) (0,1.254) (1.27,1.254)
UQFN10_19-68_80X60_0-6
  rect 0.584x0.305 smd: 1(-0.635,0.75) 4(-0.635,-0.75) 6(0.635,-0.75) 9(0.635,0.75)
  rect 0.584x0.254 smd: 2(-0.635,0.25) 3(-0.635,-0.25) 7(0.635,-0.25) 8(0.635,0.25)
  rect 0.305x0.635 smd: 5(0,-0.86) 10(0,0.86)
UQFN16_TMUX1574_70X100_0-6
  rect 0.711x0.203 smd: 1(-0.75,0.6)
  rect 0.61x0.203 smd: 2(-0.8,0.2) 3(-0.8,-0.2) 4(-0.8,-0.6) 9(0.8,-0.6) 10(0.8,-0.2) 11(0.8,0.2) 12(0.8,0.6)
  rect 0.203x0.61 smd: 5(-0.6,-1.2) 6(-0.2,-1.2) 7(0.2,-1.2) 8(0.6,-1.2) 13(0.6,1.2) 14(0.2,1.2) 15(-0.2,1.2) 16(-0.6,1.2)
USON10_TMUX1204_40X100_0-6
  rect 0.559x0.203 smd: 1(-0.417,1) 2(-0.417,0.5) 4(-0.417,-0.5) 5(-0.417,-1) 6(0.417,-1) 7(0.417,-0.5) 9(0.417,0.5) 10(0.417,1)
  rect 0.559x0.406 smd: 3(-0.417,0) 8(0.417,0)
VQFN11_TPS61089_100X80_1
  rect 0.559x0.254 smd: 1(-1.175,0.75) 2(-1.175,0.25) 3(-1.175,-0.25) 4(-1.175,-0.75) 7(1.175,-0.75) 8(1.175,-0.25) 9(1.175,0.25) 10(1.175,0.75)
  rect 0.457x1.092 smd: 5(-0.35,-0.7) 6(0.35,-0.7)
  rect 1.092x1.092 smd: 11(0,0.7)
VQFNHR9_TPS62903_80X90_1-1
  rect 0.864x0.254 smd: 1(-0.762,0.25) 2(-0.762,-0.25) 5(0.762,-0.25) 6(0.762,0.25)
  custom 0.165x0.165 smd: 3(-0.502,-0.75) 4(0.498,-0.758)
  custom 0.162x0.162 smd: 7(0.762,0.75) 9(-0.762,0.75)
  rect 0.254x0.66 smd: 8(0,0.95)
VQFNHR11_TPS62097_80X80_1
  rect 1.143x0.305 smd: 1(-0.675,0.225) 7(0.675,0.225)
  rect 2.489x0.305 smd: 2(0,-0.225)
  rect 0.254x0.584 smd: 3(-0.75,-0.912) 4(-0.25,-0.912) 5(0.25,-0.912) 6(0.75,-0.912) 8(0.75,0.912) 9(0.25,0.912) 10(-0.25,0.912) 11(-0.75,0.912)
VQFNHR12_TPS2121_80X100_1
  rect 1.041x0.406 smd: 1(-0.675,0.35) 2(-0.675,-0.35) 7(0.675,-0.35) 8(0.675,0.35)
  rect 0.203x0.61 smd: 3(-0.75,-1.15) 4(-0.25,-1.15) 5(0.25,-1.15) 6(0.75,-1.15) 9(0.75,1.15) 10(0.25,1.15) 11(-0.25,1.15) 12(-0.75,1.15)
VSSOP8_19-68_85X95
  rect 1.041x0.305 smd: 1(-1.65,0.75) 2(-1.65,0.25) 3(-1.65,-0.25) 4(-1.65,-0.75) 5(1.65,-0.75) 6(1.65,-0.25) 7(1.65,0.25) 8(1.65,0.75)
WSON8_19-68_80X80_0-8
  rect 0.711x0.305 smd: 1(-1.05,0.75) 2(-1.05,0.25) 3(-1.05,-0.25) 4(-1.05,-0.75) 5(1.05,-0.75) 6(1.05,-0.25) 7(1.05,0.25) 8(1.05,0.75)
  rect 0.965x1.702 smd: 9(0,0)
WSON8_49-99_320X240_0-8
  rect 0.94x0.457 smd: 1(-3.9,1.901) 2(-3.9,0.631) 3(-3.9,-0.639) 4(-3.9,-1.909) 5(3.9,-1.909) 6(3.9,-0.639) 7(3.9,0.631) 8(3.9,1.901)
  rect 3.454x4.369 smd: 9(0,0)
WSON10_19-68_80X120_0-8
  rect 0.711x0.305 smd: 1(-1.05,1) 2(-1.05,0.5) 3(-1.05,0) 4(-1.05,-0.5) 5(-1.05,-1) 6(1.05,-1) 7(1.05,-0.5) 8(1.05,0) 9(1.05,0.5) 10(1.05,1)
  rect 0.94x2.489 smd: 11(0,0)
X2QFN12_TUSB322I_60X60_0-4
  rect 0.711x0.203 smd: 1(-0.65,0.2) 2(-0.65,-0.2) 7(0.65,-0.2) 8(0.65,0.2)
  rect 0.203x0.508 smd: 3(-0.6,-0.75) 4(-0.2,-0.75) 5(0.2,-0.75) 6(0.6,-0.75) 9(0.6,0.75) 10(0.2,0.75) 11(-0.2,0.75) 12(-0.6,0.75)
X2SON4_TLV71318P_40X40_0-4
  custom 0.077x0.077 smd: 1(-0.43,0.325) 2(-0.43,-0.325) 3(0.43,-0.325) 4(0.43,0.325)
  rect 0.584x0.584 smd rot 45: 5(0,0)
XTAL4_ABM10W_100X80_SMD_0-6
  rect 1.194x0.838 smd: 1(-0.812,-0.6) 2(0.812,-0.6) 3(0.812,0.6) 4(-0.812,0.6)
XTAL4_NX3225GA_130X100_SMD_0-9
  rect 1.422x1.219 smd: 1(-1.1,-0.8) 2(1.1,-0.8) 3(1.1,0.8) 4(-1.1,0.8)

## Nets
DGND: C1.2 C2.2 C3.2 C4.2 C5.2 C6.1 C7.2 C8.2 C9.2 C10.2 C11.2 C12.1 C13.2 C14.2 C15.2 C16.2 C17.2 C18.2 C19.2 C20.2 C22.2 C23.2 C30.2 C31.2 C32.2 C33.2 C34.2 C35.2 C36.2 C37.2 C38.2 C43.2 C44.2 C45.2 C46.2 C47.2 C48.2 C49.2 C50.2 C51.2 C52.2 C53.2 C54.2 C57.2 C58.2 C59.2 C60.2 C61.2 C62.2 C64.2 C65.2 C66.2 C67.2 C68.2 C69.2 C70.2 C71.2 C72.2 C73.2 C74.2 C75.2 C76.2 C77.2 C78.2 C79.2 C80.2 C81.2 C82.2 C83.2 C84.2 C85.2 C86.2 C89.2 C90.2 C93.2 C94.2 C95.2 C96.2 C97.2 C98.2 C99.2 C100.2 C101.2 C102.2 C103.2 C104.2 C105.2 C106.2 C107.2 C108.2 C109.2 C110.2 C111.2 C112.2 C113.2 C114.2 C115.2 C116.2 C117.2 C118.2 C119.2 C120.2 C121.2 C122.2 C123.2 C124.2 C125.2 C126.2 C127.2 C128.2 C129.2 C130.2 C131.2 C132.2 C133.2 C134.2 C135.2 C136.2 C137.2 C138.2 C139.2 C140.2 C141.2 C142.2 C143.2 C144.2 C145.2 C146.2 C147.2 C148.2 C149.2 C150.2 C151.2 C152.2 C153.2 C154.2 C155.2 C156.2 C157.2 C158.2 C159.1 C160.2 C161.2 C162.2 C163.2 C164.1 C166.2 C167.2 C168.2 C169.2 C170.2 C171.2 C172.1 C173.2 C174.1 C175.1 C176.2 C177.2 C179.1 C181.1 C183.1 C184.2 C185.2 C186.1 C187.1 C188.2 C189.2 C190.2 C191.2 C192.2 C193.2 C195.2 C196.2 C197.2 C199.2 C206.2 C207.2 C208.2 C209.2 C210.2 C211.2 C212.2 C213.2 C214.2 C216.2 C217.2 C219.2 C220.2 C221.2 C222.2 C225.2 C226.2 C230.2 C231.2 C232.2 C233.2 C234.2 C235.2 C236.2 C237.2 C238.2 C239.2 C240.2 C241.2 C242.2 C243.2 C244.2 C245.1 C246.1 C247.2 C265.2 C272.1 C275.2 C276.2 C277.2 C278.2 C279.2 C280.2 C281.2 C282.2 C283.2 C284.2 C290.2 C291.2 C292.2 C293.2 C294.2 C295.2 C296.2 C297.2 C298.2 C299.2 C300.2 C301.2 C302.2 C303.2 C304.2 C305.2 C306.2 C307.2 C308.2 C309.2 C314.2 C315.2 C316.1 C318.2 C319.2 C320.2 C321.2 C322.2 C323.2 C324.2 C329.2 C330.1 C331.2 C332.2 C333.2 C334.2 C335.2 C336.2 C337.2 C338.2 C340.2 C341.2 C344.2 C345.2 C346.2 C347.2 C348.1 C351.1 C355.2 C356.2 C357.2 C358.2 C359.2 C360.2 C361.2 C362.2 C363.2 C364.2 C365.2 C366.2 C367.2 C368.2 C369.2 C370.2 C371.2 C372.2 C373.2 C374.2 C376.2 C377.1 C378.1 C379.1 C380.2 C3743.2 C3744.2 C3745.2 C3746.2 D1.2(ANODE) D2.2(ANODE) D3.2(A) J1.A1(GND#A1) J1.A12(GND#A12) J1.B1(GND#B1) J1.B12(GND#B12) J2.3 J3.3 J4.6(VSS) J4.10 J4.11 J4.12(CD2) J4.13 J4.14 J5.2 J6.3 J6.4 J6.9 J7.1(CH-GND) J8.1 J8.5 J8.8 J8.15 J8.16 J8.17 J8.18 J8.21 J8.24 J8.31 J8.32 J8.33 J8.34 J8.41 J8.SH1 J8.SH2 J8.SH3 J8.SH4 J9.2 J10.3 J11.7 J11.16 J11.25 J11.34 J11.40 J11.41 J11.42 J14.3 J14.4 J15.7 J15.10 J15.13 J15.16 J15.19 J15.22 J15.29 J15.32 J15.35 J15.38 J15.46 J15.47 J15.65 J15.83 J15.97 J15.111 J15.135 J15.157 J15.179 J16.2 J17.2 J18.2 J19.2 J21.2 LD2.1(CATHODE) LD3.1(CATHODE) LD5.1(CATHODE) LD8.1(CATHODE) LD19.1(CATHODE) LD20.1(CATHODE) LD21.1(CATHODE) LD22.1(CATHODE) Q2.2(S) Q3.2(S) Q4.2(S) Q6.2(S) Q7.2(S) Q8.2(S) Q9.3(D) Q10.3(D) Q11.3(D) Q21.3(D) R2.1 R7.2 R8.2 R9.1 R14.2 R15.2 R16.2 R17.2 R18.2 R42.2 R49.2 R50.2 R55.1 R56.1 R63.2 R67.2 R79.2 R82.2 R89.2 R110.2 R113.2 R134.2 R148.2 R149.2 R164.2 R165.2 R166.2 R168.1 R169.1 R170.1 R186.2 R187.2 R188.2 R189.2 R202.2 R203.2 R205.2 R206.2 R215.2 R220.1 R237.2 R238.2 R239.2 R240.2 R241.2 R242.2 R243.1 R244.1 R245.2 R264.1 R266.1 R279.2 R280.2 R281.2 R314.2 R323.1 R324.1 R325.1 R326.1 R330.1 R331.2 R389.1 R390.1 R391.1 R393.1 R396.2 R397.2 R398.2 R399.2 R400.2 R403.1 R404.1 R405.2 R407.2 R408.2 R410.2 R411.2 R414.2 R415.2 R416.2 R418.2 R434.2 R461.2 R464.2 R465.2 R469.1 R475.1 R551.2 R554.2 R1383.1 R1649.1 R3836.2 R3844.1 R3870.1 R3871.1 R3873.1 R3874.2 R3875.2 SW10.1 SW10.3 SW11.1 SW11.3 SW12.1 SW12.3 TP23.1(TP) TP24.1(TP) TP25.1(TP) TP26.1(TP) TP50.1(TP) TP77.1(TP) U1.A1(VSS#A1) U1.A18(VSS#A18) U1.E5(VSS#E5) U1.E6(VSS#E6) U1.E7(VSS#E7) U1.E8(VSS#E8) U1.E10(VSS#E10) U1.E12(VSS#E12) U1.E13(VSS#E13) U1.E14(VSS#E14) U1.F5(VSS#F5) U1.F6(VSS#F6) U1.F7(VSS#F7) U1.F8(VSS#F8) U1.F10(VSS#F10) U1.F12(VSS#F12) U1.F13(VSS#F13) U1.F14(VSS#F14) U1.G7(VSS#G7) U1.G8(VSS#G8) U1.G9(VSS#G9) U1.G10(VSS#G10) U1.G11(VSS#G11) U1.G12(VSS#G12) U1.H5(VSS#H5) U1.H6(VSS#H6) U1.H7(VSS#H7) U1.H8(VSS#H8) U1.H9(VSS#H9) U1.H10(VSS#H10) U1.H11(VSS#H11) U1.H12(VSS#H12) U1.H13(VSS#H13) U1.H14(VSS#H14) U1.J5(VSS#J5) U1.J6(VSS#J6) U1.J7(VSS#J7) U1.J8(VSS#J8) U1.J9(VSS#J9) U1.J10(VSS#J10) U1.J11(VSS#J11) U1.J12(VSS#J12) U1.J13(VSS#J13) U1.J14(VSS#J14) U1.K7(VSS#K7) U1.K8(VSS#K8) U1.K9(VSS#K9) U1.K10(VSS#K10) U1.K11(VSS#K11) U1.K12(VSS#K12) U1.L5(VSS#L5) U1.L6(VSS#L6) U1.L7(VSS#L7) U1.L8(VSS#L8) U1.L9(VSS#L9) U1.L10(VSS#L10) U1.L11(VSS#L11) U1.L12(VSS#L12) U1.L13(VSS#L13) U1.L14(VSS#L14) U1.M5(VSS#M5) U1.M6(VSS#M6) U1.M7(VSS#M7) U1.M8(VSS#M8) U1.M9(VSS#M9) U1.M10(VSS#M10) U1.M11(VSS#M11) U1.M12(VSS#M12) U1.M13(VSS#M13) U1.M14(VSS#M14) U1.N7(VSS#N7) U1.N8(VSS#N8) U1.N9(VSS#N9) U1.N10(VSS#N10) U1.N11(VSS#N11) U1.N12(VSS#N12) U1.P5(VSS#P5) U1.P6(VSSA#P6) U1.P8(VSSA#P8) U1.P10(VSSA#P10) U1.P12(VSSA#P12) U1.P13(VSS#P13) U1.P14(VSS#P14) U1.R5(VSSA#R5) U1.R13(VSSA#R13) U1.T2(VSS#T2) U1.V1(VSSA#V1) U1.V18(VSSA#V18) U2.3(GND) U3.5(GND) U3.9(EP) U4.9(ST) U4.12(GND) U5.5(GND) U7.1(PGND#1) U7.2(PGND#2) U7.14(LGND) U7.47(PGND#47) U7.48(PGND#48) U7.49(EPAD) U8.8(GND) U9.4(GND) U9.7(MODE/S-CONF) U10.1(PGND) U10.5(FB) U10.6(AGND) U10.11(EP) U12.1(A1) U12.2(A0) U12.7(GND) U13.1(A1) U13.7(GND) U14.1(PGND) U14.11(AGND) U15.2(GND) U15.5(EP) U16.2(GND) U17.10(GND) U18.4(GND) U18.9(EP) U19.B3(VSS) U19.C1(VSSQ#C1) U19.E5(VSSQ#E5) U20.8(GND) U21.3(GND) U22.3(GND) U23.2(GND) U24.5(GND) U25.4(GND) U26.8(GND) U27.5(GND) U28.4(GND) U29.2(GND) U30.8(GND) U31.5(GND2) U32.4(GND1) U33.8(GND) U35.49(GND) U36.3(GND) U39.3(GND) U41.4(GND) U42.2(GND) U43.3(GND) U44.8(GND) U45.5(GND) U46.4(GND1) U47.6(GND) U47.17(EP) U48.10(GND1) U48.11(GND2) U49.3(GND) U50.3(GND) U54.4(GND1) U56.5(GND2) U57.9(GND2) U58.5(GND2) U58.6(OUTB) U59.8(G\) U59.16(GND) U60.25(GND) U60.33(EP) U61.2(GND) U62.2(GND) U63.2(GND) U64.2(GND) U65.2(GND) U66.3(GND) U66.7(EP) U67.13(-V) U68.2(GND) U69.2(GND) U70.3(GND) U72.8(GND) U73.8(GND) U74.3(GND) U75.3(GND) U76.4(GND) U78.2(GND) U79.3(GND) U80.43(GND) U81.5(GND) U82.43(GND) U84.43(GND) U85.43(GND) U87.43(GND) U88.43(GND) U89.43(GND) U90.5(GND) Y1.2(GND1) Y1.4(GND2)
V3V3_XDS_FB: C248.2 R332.2 R333.1 U51.5(NR/FB)
VBAT_LIN: D7.2(A) J9.1
VBAT_XDS: C262.1 R334.2 U52.68(VBAT)
VBUS_DET: R5.1 U17.4(VBUS_DET)
VBUS_MAIN: C7.1 R10.1 R11.1 U3.7(VOUT1) U3.8(VOUT2) U4.2(IN2)
VBUS_USBC: C1.1 C2.1 C3.1 C4.1 C5.1 C8.1 D3.1(K) J1.A4(VBUS1) J1.A9(VBUS2) J1.B4(VBUS3) J1.B9(VBUS4) R1.1 R3.1 R4.1 R5.2 R6.1 TP2.1(TP) U2.5(VCC) U3.1(VIN1) U3.2(VIN2) U3.4(VBIAS) U17.12(VDD)
VBUS_XDS110: C256.1 J13.1(VBUS) R339.2 R340.1 TP66.1(TP) U51.1(IN1) U51.2(IN2) U51.8(EN) U53.6(VCC)
VCC2V5_PG: R80.2 R81.1 U14.5(PG) U16.3(ON)
VCC3V3_XDS: C180.2 C182.2 C248.1 C249.1 C250.1 C251.1 C252.1 C253.1 C254.1 C255.1 C257.1 C258.1 C266.1 C271.2 C273.2 C274.1 C352.1 R306.2 R332.1 R334.1 R345.2 R346.2 R347.2 R348.2 R353.1 R354.1 R356.1 R357.1 R359.1 R360.1 R365.1 R366.1 R367.1 R368.1 R369.1 R370.1 R377.1 TP67.1(TP) U31.1(VCC1) U32.8(VCC2) U51.3(OUT1) U51.4(OUT2) U52.7(VDD#7) U52.8(VDDA) U52.16(VDD#16) U52.26(VDD#26) U52.28(VDD#28) U52.39(VDD#39) U52.47(VDD#47) U52.51(VDD#51) U52.52(VDD#52) U52.69(VDD#69) U52.79(VDD#79) U52.90(VDD#90) U52.101(VDD#101) U52.113(VDD#113) U52.122(VDD#122) U54.8(VCC2) U56.1(VCC1) U57.1(VCC1) U58.1(VCC1)
VCC_1V1: C97.1 FL4.1 TP30.1(TP) U15.1(OUT)
VCC_1V2: C102.1 C103.1 C110.1 C111.1 C112.1 C113.1 C114.1 C115.1 C116.1 C117.1 C118.1 C119.1 C120.1 C121.1 C122.1 C123.1 C124.1 C125.1 C126.1 C127.1 C128.1 C129.1 C130.1 C131.1 C132.1 C133.1 R75.2 TP28.1(TP) U1.D10(VDDAR2) U1.E9(VDD#E9) U1.E11(VDD#E11) U1.F9(VDD#F9) U1.F11(VDD#F11) U1.G5(VDD#G5) U1.G6(VDD#G6) U1.G13(VDD#G13) U1.G14(VDD#G14) U1.H3(VDDAR3) U1.J15(VDDAR1) U1.J16(VDD#J16) U1.K5(VDD#K5) U1.K6(VDD#K6) U1.K13(VDD#K13) U1.K14(VDD#K14) U1.N5(VDD#N5) U1.N6(VDD#N6) U1.N13(VDD#N13) U1.N14(VDD#N14) U1.R9(VDD_F)
VCC_1V2_N: R70.2 R75.1
VCC_1V2_P: R68.2 R75.4
VCC_1V8_LDO4: C70.1 C71.1 C72.1 R36.2 R3833.1 SW7.1 TP20.1(TP) U7.30(LDO4_OUT)
VCC_2V5_EN: R78.1 U14.6(EN)
VCC_5V0: C174.2 FB1.2 J15.117 U29.3(VCC)
VCC_6V0_BBOUT: C30.1 C31.1 C32.1 C33.1 C34.1 C35.1 C36.1 C37.1 C38.1 C80.1 C344.1 C345.1 TP5.1(TP) U7.41(LDO_IN) U7.42(BB_OUT) U9.6(VIN) U66.6(IN)
VCC_PLDO1: C74.1 C75.1 C76.1 J3.1 U7.20(PLDO1_OUT)
VCC_PLDO2: C77.1 C78.1 C79.1 J2.1 U7.29(PLDO2_OUT)
VDD1V1A: C190.1 C191.1 C192.1 C193.1 C195.1 C196.1 C197.1 C199.1 FL4.2 U35.6(VDDA1P1) U35.31(VDD1P1#31) U35.39(VDD1P1#39)
VDD2V5A: C206.1 C207.1 C208.1 C209.1 C210.1 C211.1 FL5.2 U35.3(VDDA2P5#3) U35.9(VDDA2P5#9)
VDD_2V5: C94.1 C96.1 C220.1 C221.1 FL5.1 J8.4 J8.6 L6.2 R77.2 TP29.1(TP) U14.3(VOS) U15.4(IN)
VDD_5V0_LDO3: C67.1 C68.1 C69.1 FB1.1 R381.2 R382.2 R383.2 R384.2 R385.2 R386.2 R387.2 R388.2 R3834.1 SW4.1 TP19.1(TP) U7.15(LDO3_OUT)
VDD_IO_3V3: C138.1 C139.1 C147.1 C148.1 C149.1 C150.1 C151.1 C152.1 C153.1 C154.1 C155.1 C156.1 FL1.1 R74.2 TP27.1(TP) U1.D8(VDDS33#D8) U1.D12(VDDS33#D12) U1.H4(VDDS33#H4) U1.H15(VDDS33#H15) U1.L15(VDDS33#L15) U1.P4(VDDS33#P4) U1.R15(VDDS33#R15)
VDD_IO_3V3_N: R71.2 R74.1
VDD_IO_3V3_P: R69.2 R74.4
VDD_MMC1: C169.1 C170.1 J4.4(VDD) TP51.1(TP) U23.5(QOD) U23.6(VOUT)
VDDA1V8_OSC_PLL_F: C146.1 FL2.2 U1.R4(VDDA18_OSC_PLL)
VDDA3V3_F: C134.1 C135.1 C136.1 C137.1 FL1.2 U1.P7(VDDA33#P7) U1.P9(VDDA33#P9) U1.P11(VDDA33#P11)
VDDA_IO_1V8: C140.1 C141.1 C142.1 C143.1 C144.1 C145.1 FL2.1 R467.1 SW8.1 U1.R6(VDDA18_LDO) U1.R8(VDDA18#R8) U1.R11(VDDA18#R11)
VDDA_IO_3V3: C281.1 C282.1 C283.1 C284.1 C314.1 C315.1 C316.2 C329.1 C330.2 FL7.2 R406.1 R409.1 U61.5(VCC) U62.5(VCC) U63.5(VCC) U64.5(VCC) U65.5(VCC) U67.4(+V) U68.5(VCC) U69.5(VCC) U70.8(VDD) U72.16(VCC) U73.16(VCC) U74.8(VDD) U75.8(VDD)
VDDC_1V2_XDS: C259.1 C260.1 C261.1 U52.87(VDDC#87) U52.115(VDDC#115)
VDDIO: C100.1 C212.1 C213.1 C214.1 C216.1 C217.1 C219.1 C225.1 C226.1 FL3.1 J8.44 J8.46 R216.2 R218.1 R219.1 R225.1 R226.1 R227.1 R228.1 R229.1 R230.2 R231.2 R232.2 R233.2 U16.5(QOD) U16.6(VOUT) U35.18(VDDIO#18) U35.30(VDDIO#30)
VDDS_IO_1V8: C104.1 C105.1 C106.1 C107.1 C108.1 C109.1 U1.D6(VDDS18#D6) U1.E15(VDDS18#E15) U1.L4(VDDS18#L4) U1.N15(VDDS18#N15) U1.T3(VDDS18_LDO) U43.5(VCC)
1588_SFD: J8.38 R3881.2
ADC1_MUX_SEL: R414.1 U60.15(P16) U74.1(SEL1) U74.5(SEL2)
ADC2_MUX_SEL: R415.1 U60.16(P17) U75.1(SEL1) U75.5(SEL2)
ADC3_MUX_SEL: R405.1 U60.6(P05) U70.1(SEL1) U70.5(SEL2)
ADC4_AIN0/ADC_CAL0/ADC_R0_AIN0: C306.1 J15.25 U61.4(IO3) U75.10(D1)
ADC4_AIN1/ADC_CAL1/ADC_R0_AIN1: C307.1 J15.27 U61.6(IO4) U75.6(D2)
ADC4_MUX_OE#: R407.1 U72.15(O\E\)
ADC4_MUX_SEL: R406.2 R408.1 U60.7(P06) U72.1(S)
ADC5_MUX_OE#: R410.1 U73.15(O\E\)
ADC5_MUX_SEL: R409.2 R411.1 U60.9(P10) U73.1(S)
ADC_CAL0: U1.U16(ADC_CAL0) U73.2(1B1)
ADC_CAL0/ADC_R0_AIN0: U73.4(1A) U75.9(S1B)
ADC_CAL1: U1.T15(ADC_CAL1) U70.4(S2A)
ADC_CAL1/ADC_R0_AIN1: U70.6(D2) U75.7(S2B)
ADC_CAL2: J14.1 U1.U17(ADC_CAL2) U65.4(IO3)
ADC_CAL3: J14.2 U1.N17(ADC_CAL3) U65.6(IO4)
ADC_DAC-VREF: SW7.2(COM) U67.3(+INA) U67.5(+INB) U67.12(+INC) U67.14(+IND)
ADC_R0_AIN0: U1.T18(ADC_R0_AIN0) U73.3(1B2)
ADC_R0_AIN1: U1.T16(ADC_R0_AIN1) U70.7(S2B)
ADC_R0_AIN2: U1.U18(ADC_R0_AIN2) U72.3(1B2)
ADC_R0_AIN3: U1.T17(ADC_R0_AIN3) U72.6(2B2)
ADC_R1_AIN0: U1.R16(ADC_R1_AIN0) U73.6(2B2)
ADC_R1_AIN1: U1.R18(ADC_R1_AIN1) U70.9(S1B)
ADC_R1_AIN2: U1.P18(ADC_R1_AIN2) U72.10(3B2)
ADC_R1_AIN3: U1.P17(ADC_R1_AIN3) U72.13(4B2)
