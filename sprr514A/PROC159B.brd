# Allegro board PROC159B.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
HSEC_MMC0_CLK: length 104.8
  TOP w0.147: J15.163 105.64,3.79 106.21,4.36 106.21,6.02 v1(105.64,6.59)
  L08_SIG2 w0.091: v1(105.64,6.59) 104.91,7.32 103.12,7.32 101.52,8.92 100.16,8.92 91.97,17.11 89.4,17.11 88.94,17.57 88.94,18.02 89.34,18.41 89.34,18.6 89.2,18.74 89.01,18.74 88.62,18.34 88.43,18.34 87.52,19.25 87.52,19.44 87.95,19.87 87.95,20.06 87.81,20.2 87.62,20.2 87.19,19.76 87,19.76 86.87,19.9 86.87,20.09 87.3,20.52 87.3,20.71 87.17,20.84 86.98,20.84 86.55,20.41 86.36,20.41 86.22,20.55 86.22,20.73 86.65,21.17 86.65,21.36 86.52,21.49 86.33,21.49 85.9,21.06 85.71,21.06 85.58,21.19 85.58,21.38 86.01,21.81 86.01,22 85.87,22.14 85.68,22.14 85.25,21.7 85.06,21.7 84.88,21.89 84.88,22.45 85.01,22.59 85.41,22.59 85.55,22.72 85.55,22.91 85.41,23.05 85.01,23.05 84.88,23.18 84.88,23.37 85.01,23.5 85.41,23.5 85.55,23.64 85.55,23.83 85.41,23.96 85.01,23.96 84.88,24.09 84.88,24.28 85.01,24.42 85.41,24.42 85.55,24.55 85.55,24.74 85.41,24.87 85.01,24.87 84.88,25.01 84.88,25.2 85.01,25.33 85.41,25.33 85.55,25.47 85.55,25.66 85.41,25.79 84.99,25.79 84.27,26.5 84.27,27.71 81.06,30.93 81.06,32.22 80.09,33.19 80.09,39.04 78.49,40.65 78.49,49.09 75.7,51.88 71.22,51.88 70.19,52.91 68.11,52.91 67.35,53.66 66.35,53.66 65.19,54.83 59.19,54.83 58.24,53.88 52.04,53.88 v1(51.14,52.98)
  BOTTOM w0.147: v1(51.14,52.98) 50.86,52.98 50.49,52.6 RA3.4
HSEC_MMC0_CMD: length 105
  L08_SIG2 w0.091: v1(105.64,5.58) 106.25,4.96 106.25,4.67 106.79,4.13 107.49,4.13 107.96,4.61 107.96,7.91 107.41,8.47 103.59,8.47 103.04,9.01 103.04,9.28 100.51,11.81 99.92,11.81 97.99,13.74 97.07,13.74 92.78,18.03 92.78,19.16 92.17,19.77 92.17,22.72 84.22,30.67 84.22,31.85 83.54,32.54 83.54,40.15 81.71,41.98 81.71,44.83 79.58,46.96 79.58,50.83 77.45,52.97 71.6,52.97 70.89,53.68 68.43,53.68 67.67,54.44 66.67,54.44 65.51,55.6 58.93,55.6 58.09,54.76 48.35,54.76 v1(46.57,52.98)
  BOTTOM w0.147: v1(105.64,5.58) 105.18,5.12 105.18,4.37 105.64,3.92 J15.164 ; v1(46.57,52.98) 46.57,52.94 46.3,52.66 RA5.3
HSEC_MMC0_D0: length 104.9
  TOP w0.147: J15.165 106.44,4.03 106.66,4.26 106.66,6.02 v1(107.24,6.59)
  L08_SIG2 w0.091: v1(50.12,52.98) 51.21,54.06 58.17,54.06 59.13,55.02 65.27,55.02 66.43,53.86 67.43,53.86 68.19,53.1 70.34,53.1 71.33,52.11 75.78,52.11 78.76,49.13 78.76,46.29 80.11,44.93 80.11,44.41 79.98,44.28 79.6,44.28 79.47,44.15 79.47,43.96 79.6,43.82 79.98,43.82 80.11,43.69 80.11,43.5 79.98,43.37 79.6,43.37 79.47,43.23 79.47,43.04 79.6,42.91 79.98,42.91 80.11,42.77 80.11,42.59 79.98,42.45 79.6,42.45 79.47,42.32 79.47,42.13 79.6,41.99 79.98,41.99 80.11,41.86 80.11,41.67 79.98,41.54 79.6,41.54 79.47,41.4 79.47,41.21 79.6,41.08 79.98,41.08 80.11,40.95 80.11,39.7 82.24,37.57 82.24,37.07 82.11,36.94 81.73,36.94 81.59,36.81 81.59,36.62 81.73,36.48 82.11,36.48 82.24,36.35 82.24,36.16 82.11,36.02 81.73,36.02 81.59,35.89 81.59,35.7 81.73,35.57 82.11,35.57 82.24,35.43 82.24,35.24 82.11,35.11 81.73,35.11 81.59,34.98 81.59,34.79 81.73,34.65 82.11,34.65 82.24,34.52 82.24,34.33 82.11,34.2 81.73,34.2 81.59,34.06 81.59,33.87 81.73,33.74 82.11,33.74 82.24,33.61 82.24,33.42 82.11,33.28 81.73,33.28 81.59,33.15 81.59,32.96 81.73,32.82 82.11,32.82 82.24,32.69 82.24,32.5 82.11,32.37 81.73,32.37 81.59,32.23 81.59,32.04 81.73,31.91 82.11,31.91 82.24,31.78 82.24,30.21 84.68,27.77 84.68,27.01 86.33,25.36 86.33,22.36 89.35,19.34 89.89,19.34 90.39,18.83 91.16,18.83 91.69,18.3 91.69,17.78 100.28,9.19 101.7,9.19 103.25,7.64 106.18,7.64 v1(107.24,6.59)
  BOTTOM w0.147: v1(50.12,52.98) 50.12,52.94 49.85,52.66 RA3.3
HSEC_MMC0_D1: length 105.2
  L08_SIG2 w0.091: v1(107.24,5.58) 106.76,6.05 104,6.05 101.41,8.64 100.05,8.64 92.5,16.19 88.31,16.19 86.54,17.97 86.54,18.18 86.75,18.4 86.75,18.59 86.62,18.72 86.43,18.72 86.21,18.5 86.02,18.5 85.89,18.64 85.89,18.83 86.11,19.04 86.11,19.23 85.97,19.37 85.78,19.37 85.57,19.15 85.38,19.15 85.24,19.29 85.24,19.47 85.46,19.69 85.46,19.88 85.33,20.01 85.14,20.01 84.92,19.8 84.73,19.8 84.37,20.16 83.8,20.16 83.66,20.3 83.66,20.49 83.8,20.62 84.23,20.62 84.36,20.75 84.36,20.94 84.23,21.08 83.8,21.08 83.66,21.21 83.66,21.4 83.8,21.53 84.23,21.53 84.36,21.67 84.36,21.86 84.23,21.99 83.8,21.99 83.66,22.13 83.66,22.31 83.8,22.45 84.23,22.45 84.36,22.58 84.36,24.01 84.23,24.14 83.9,24.14 83.76,24.28 83.76,24.47 83.9,24.6 84.23,24.6 84.36,24.73 84.36,24.92 84.23,25.06 83.9,25.06 83.76,25.19 83.76,25.38 83.9,25.51 84.23,25.51 84.36,25.65 84.36,25.84 84.23,25.97 83.9,25.97 83.76,26.1 83.76,27.82 80.78,30.79 80.78,32.1 79.82,33.07 79.82,38.93 78.21,40.54 78.21,49.1 75.63,51.68 71.08,51.68 70.05,52.71 68.03,52.71 67.27,53.47 66.27,53.47 65.11,54.63 59.27,54.63 58.33,53.7 52.66,53.7 51.45,52.49 49.6,52.49 v1(49.11,52.98)
  BOTTOM w0.147: v1(107.24,5.58) 106.44,4.78 J15.166 ; RA3.2 49.35,52.69 49.11,52.94 v1(49.11,52.98)
HSEC_MMC0_D2: length 104.9
  TOP w0.147: J15.167 v1(107.24,4.56)
  L08_SIG2 w0.091: v1(48.22,52.98) 48.22,53.58 48.45,53.81 48.89,53.81 49.51,54.43 58.02,54.43 59,55.41 65.43,55.41 66.59,54.24 67.59,54.24 68.35,53.48 70.72,53.48 71.51,52.69 77.34,52.69 79.31,50.72 79.31,46.78 81.4,44.69 81.4,41.83 83.12,40.12 83.12,30.4 85.47,28.05 85.47,27.17 87.02,25.61 87.02,24.24 87.23,24.03 87.42,24.03 87.69,24.3 87.88,24.3 88.01,24.16 88.01,23.97 87.74,23.7 87.74,23.52 87.88,23.38 88.07,23.38 88.34,23.65 88.52,23.65 88.66,23.52 88.66,23.33 88.39,23.06 88.39,22.87 88.52,22.73 88.71,22.73 88.98,23 89.17,23 89.31,22.87 89.31,22.68 89.04,22.41 89.04,22.22 89.17,22.09 89.36,22.09 89.63,22.36 89.82,22.36 89.95,22.22 89.95,22.03 89.68,21.77 89.68,21.58 89.82,21.44 90.01,21.44 90.28,21.71 90.46,21.71 90.6,21.58 90.6,21.39 90.33,21.12 90.33,20.93 90.46,20.8 90.65,20.8 90.92,21.06 91.11,21.06 91.25,20.93 91.25,20.74 90.98,20.47 90.98,20.26 92.45,18.78 92.45,17.97 96.95,13.47 97.88,13.47 99.42,11.92 99.42,11.37 99.96,10.83 100.84,10.83 103.48,8.19 107.29,8.19 107.69,7.8 107.69,5.01 v1(107.24,4.56)
  BOTTOM w0.147: v1(48.22,52.98) 48.22,52.6 RA3.1
HSEC_MMC0_D3: length 105.3
  L08_SIG2 w0.091: v1(47.33,52.98) 47.76,52.55 48.4,52.55 48.68,52.84 48.68,53.15 49.77,54.24 58.09,54.24 59.06,55.21 65.35,55.21 66.51,54.05 67.51,54.05 68.27,53.29 70.53,53.29 71.4,52.42 77.22,52.42 79.03,50.61 79.03,46.55 81.09,44.5 81.09,41.59 82.67,40 82.67,30.34 85.11,27.9 85.11,27.11 86.63,25.59 86.63,22.91 86.77,22.77 86.96,22.77 87.29,23.1 87.48,23.1 87.61,22.96 87.61,22.78 87.28,22.45 87.28,22.26 87.42,22.13 87.61,22.13 87.93,22.45 88.12,22.45 88.26,22.32 88.26,22.13 87.93,21.8 87.93,21.61 88.06,21.48 88.25,21.48 88.58,21.81 88.77,21.81 88.9,21.67 88.9,21.48 88.58,21.16 88.58,20.97 88.71,20.83 88.9,20.83 89.23,21.16 89.42,21.16 89.55,21.03 89.55,20.84 89.22,20.51 89.22,20.08 89.58,19.72 91,19.72 92.12,18.61 92.12,17.91 96.84,13.19 97.73,13.19 99.15,11.77 99.15,10.71 100.34,9.51 101.77,9.51 103.36,7.92 106.93,7.92 v1(107.24,7.61)
  BOTTOM w0.147: J15.168 107.24,3.92 107.73,4.41 107.73,7.11 v1(107.24,7.61) ; RA5.4 47.33,52.5 v1(47.33,52.98)
HSEC_MMC0_SDCD: length 102.5
  L08_SIG2 w0.091: v1(108.84,6.59) 108.32,7.11 108.32,8.1 107.54,8.88 105.38,8.88 104.79,9.48 103.37,9.48 100.73,12.11 100.07,12.11 98.47,13.7 98.47,13.89 97.6,14.76 96.44,14.76 93.11,18.09 93.11,22.19 84.58,30.72 84.58,31.93 83.93,32.59 83.93,40.38 82.01,42.29 82.01,45.02 79.86,47.17 79.86,50.95 77.56,53.24 71.6,53.24 70.97,53.87 68.56,53.87 67.8,54.63 66.75,54.63 65.59,55.79 58.86,55.79 58.01,54.94 47.52,54.94 v1(45.55,52.98)
  BOTTOM w0.147: v1(45.55,52.98) 45.55,52.94 45.8,52.69 RA5.2 ; v1(108.84,6.59) 108.04,5.79 J15.170
HSEC_MMC0_WP: length 104.6
  TOP w0.147: v1(108.84,7.61) 108.04,6.81 J15.169
  L08_SIG2 w0.091: v1(45.59,53.8) 46.91,55.12 57.94,55.12 58.8,55.99 65.55,55.99 65.89,56.33 66.39,56.33 67.18,55.53 67.71,55.53 67.98,55.26 67.98,54.76 68.61,54.14 70.98,54.14 71.6,53.52 77.68,53.52 80.13,51.06 80.13,47.28 82.28,45.13 82.28,42.5 84.31,40.47 84.31,32.68 84.98,32.02 85.57,32.02 94.05,23.53 94.05,17.53 96.55,15.04 97.71,15.04 99.23,13.52 100.07,13.52 101.87,11.71 101.87,11.36 103.48,9.75 104.95,9.75 105.49,9.21 107.69,9.21 108.84,8.06 v1(108.84,7.61)
  BOTTOM w0.147: RA5.1 45.16,52.63 44.98,52.81 44.98,53.2 v1(45.59,53.8)
HSEC_SDFM0_CLK0: length 64.2
  TOP w0.147: U1.B16 v1(65.78,46.43)
  L08_SIG2 w0.091: v1(48.64,5.58) 49.89,5.58 55.19,10.87 56.97,10.87 59.35,13.26 59.35,14.46 62.81,17.92 65.82,17.92 66.6,18.71 66.6,22.32 67.64,23.36 67.64,25.7 69.45,27.51 69.45,33.54 70.13,34.22 70.13,40.25 69.34,41.04 68.67,41.04 67.69,42.02 64.04,42.02 63.79,42.27 63.79,45.79 64.02,46.02 65.37,46.02 v1(65.78,46.43)
  BOTTOM w0.147: J15.72 48.64,3.92 48.18,4.37 48.18,5.12 v1(48.64,5.58)
HSEC_SDFM0_CLK1: length 59.3
  TOP w0.147: R422.2 63.82,49.19 v1(65.78,47.23) U1.A16 ; v1(61.44,6.59) 60.64,5.79 J15.101
  L08_SIG2 w0.091: v1(61.44,6.59) 59.85,8.18 59.85,10.75 65.11,16 66.84,16 69.56,18.72 69.56,22.93 68.73,23.76 68.73,24.41 68.68,24.45 68.68,25.36 68.73,25.41 68.73,25.44 70.25,26.96 70.25,33.25 71.8,34.8 71.8,38.64 71.15,39.29 71.15,40.87 66.64,45.38 66.64,46.75 66.15,47.23 v1(65.78,47.23)
HSEC_SDFM0_CLK2: length 63.4
  TOP w0.147: U1.B15 v1(64.98,46.43) ; v1(63.03,6.5) 62.24,5.71 J15.105
  L08_SIG2 w0.091: v1(64.98,46.43) 65.23,46.43 65.62,46.82 65.97,46.82 66.36,46.43 66.36,45.3 70.86,40.8 70.86,34.13 70.03,33.3 70.03,27.06 68.37,25.4 68.37,23.75 69.31,22.81 69.31,18.75 67.23,16.66 63.79,16.66 58.56,11.43 58.56,7.49 59.14,6.91 59.14,6.53 59.64,6.04 59.98,6.04 60.63,5.38 60.63,4.76 61.26,4.13 61.62,4.13 62.61,5.12 62.61,6.07 v1(63.03,6.5)
HSEC_SDFM0_CLK3: length 56.8
  TOP w0.147: v1(63.72,10.39) 63.72,9.94 63.88,9.77 63.88,4.44 63.84,4.4 J15.109 ; U1.A15 v1(64.98,47.23)
  L08_SIG2 w0.091: v1(63.72,10.39) 63.98,10.65 63.98,12.6 69.43,18.05 71.5,18.05 72.25,18.8 72.25,22.76 71.17,23.84 71.17,28.21 71.5,28.54 71.5,31.79 71.29,31.99 71.29,32.66 71.5,32.87 71.5,33.91 72.25,34.65 72.25,38.89 71.64,39.5 71.64,41.07 68.1,44.61 68.1,47.1 67.38,47.82 65.2,47.82 64.98,47.6 v1(64.98,47.23)
HSEC_SDFM0_D0: length 53.6
  TOP w0.147: U1.D14 v1(64.18,44.83) ; J15.91 v1(56.64,4.56)
  L08_SIG2 w0.091: v1(64.18,44.83) 64.59,44.42 66.54,44.42 70.37,40.6 70.37,34.19 69.64,33.46 69.64,27.36 67.89,25.6 67.89,23.29 66.82,22.23 66.82,18.62 66.08,17.88 66.08,17.33 65.77,17.02 63.63,17.02 57.73,11.12 57.73,5.65 v1(56.64,4.56)
HSEC_SDFM0_D1: length 85.7
  TOP w0.147: U1.D13 v1(63.38,44.83) ; J15.99 v1(59.84,4.56)
  L08_SIG2 w0.091: v1(59.84,4.56) 60.81,3.58 62.93,3.58 63.65,4.31 63.65,6.72 66.72,9.78 66.93,10 66.93,12.29 69.22,14.58 74.45,14.58 77.21,17.33 77.21,21.55 80.95,25.29 80.95,28.49 78.21,31.23 78.21,37.23 76.43,39.02 76.43,42.76 75.95,43.23 75.95,44.06 73.27,46.75 73.27,48.62 72.32,49.57 69.71,49.57 68.69,50.59 68.46,50.59 68.29,50.76 68.29,51.25 68,51.54 67.52,51.54 66.75,52.31 65.45,52.31 v1(64.66,53.1)
  BOTTOM w0.114: v1(63.38,44.83) 63.78,45.23 63.78,47.56
  BOTTOM w0.147: 63.78,47.56 63.78,48.42 64.66,49.31 v1(64.66,53.1) R421.2
HSEC_SDFM0_D2: length 68.9
  TOP w0.147: J15.103 v1(61.44,4.56) ; U1.C13 v1(63.38,45.63)
  L08_SIG2 w0.091: v1(61.44,4.56) 61.01,4.99 61.01,5.67 61.28,5.94 61.65,5.94 62.05,6.34 62.05,7.6 61.56,8.08 60.88,8.08 60.4,8.56 60.4,10.4 61.08,11.08 61.44,11.08 62.77,9.75 64.41,9.75 65.12,10.46 65.12,13.23 69.59,17.69 71.83,17.69 72.73,18.59 72.73,22.86 73.66,23.78 73.66,25.93 72.72,26.87 72.72,29.21 73.15,29.65 73.15,30.71 72.63,31.23 72.63,34.16 72.95,34.48 72.95,41.82 70.89,43.88 69.81,43.88 68.6,45.09 68.6,47.29 67.58,48.31 64.71,48.31 63.79,47.39 63.79,46.08 63.38,45.66 v1(63.38,45.63)
HSEC_SDFM0_D3: length 59.3
  TOP w0.147: J15.107 v1(63.04,4.56) ; U1.C14 v1(64.18,45.63)
  L08_SIG2 w0.091: v1(63.04,4.56) 62.43,3.95 61.19,3.95 60.45,4.69 60.45,5.31 59.9,5.85 59.56,5.85 58.79,6.62 58.79,6.88 58.38,7.29 58.38,11.51 63.71,16.84 67.15,16.84 69.07,18.76 69.07,22.71 68.13,23.65 68.13,25.5 69.83,27.21 69.83,33.38 70.62,34.16 70.62,40.7 66.1,45.22 64.59,45.22 v1(64.18,45.63)
HSEC_SPI0_CLK: length 78.5
  TOP w0.147: R139.1 v1(61.41,51.73) R150.1 ; J15.71 v1(48.64,4.56)
  L08_SIG2 w0.091: v1(48.64,4.56) 48.08,4 45.39,4 45.01,4.38 45.01,7.04 49.76,11.78 56.84,11.78 58.45,13.39 58.45,14.83 62.44,18.83 65.44,18.83 65.7,19.08 65.7,22.69 66.67,23.66 66.67,26.18 67.4,26.91 67.4,31.67 67.98,32.26 67.98,39.46 67.59,39.86 60.83,39.86 60.06,40.63 60.06,46.75 61.41,48.1 v1(61.41,51.73)
HSEC_SPI0_CS0: length 63.5
  TOP w0.147: U1.C11 v1(61.78,45.63) ; v1(50.24,6.59) 49.44,5.79 J15.73
  L08_SIG2 w0.091: v1(50.24,6.59) 50.65,6.59 55.12,11.06 56.89,11.06 59.13,13.3 59.13,14.55 62.72,18.14 65.73,18.14 66.39,18.8 66.39,22.41 67.4,23.42 67.4,25.81 69.26,27.66 69.26,33.62 69.89,34.25 69.89,35.36 69.12,36.13 69.12,38.73 69.62,39.23 69.62,40.25 69.17,40.69 68.32,40.69 67.77,41.24 61.62,41.24 61.39,41.47 61.39,45.24 v1(61.78,45.63)
HSEC_SPI0_D0: length 70.3
  TOP w0.147: U1.C10 v1(60.98,45.63) ; J15.67 v1(47.04,4.56)
  L08_SIG2 w0.091: v1(60.98,45.63) 60.59,45.24 60.59,40.67 60.87,40.39 68.78,40.39 69.3,39.87 69.3,39.36 68.85,38.91 68.85,34.75 69.06,34.54 69.06,32.47 67.88,31.29 67.88,26.71 67.15,25.98 67.15,23.49 66.17,22.5 66.17,18.89 65.64,18.36 62.63,18.36 58.92,14.64 58.92,13.34 56.82,11.24 55.04,11.24 50.85,7.05 49.9,7.05 48.91,6.06 48.16,6.06 47.04,4.93 v1(47.04,4.56)
  BOTTOM w0.147: R151.1 61.47,48.48 60.45,47.46 60.45,46.16 v1(60.98,45.63)
HSEC_SPI0_D1: length 65.1
  TOP w0.147: U1.B11 v1(61.78,46.43) ; J15.69 47.84,5.79 v1(48.64,6.59)
  L08_SIG2 w0.091: v1(61.78,46.43) 61.37,46.02 60.73,46.02 60.35,45.64 60.35,40.63 60.86,40.12 67.72,40.12 68.19,39.65 68.19,32 67.64,31.45 67.64,26.81 66.91,26.08 66.91,23.59 65.92,22.6 65.92,18.99 65.53,18.61 62.53,18.61 58.67,14.74 58.67,13.35 56.74,11.42 53.19,11.42 48.96,7.19 48.96,6.91 v1(48.64,6.59)
HSEC_SPI1_CLK: length 17.1
  TOP w0.147: J15.79 v1(51.84,4.56) ; U8.3 v1(61.26,10.66)
  L03_SIG1 w0.091: v1(61.26,10.66) 61.68,10.24 61.68,8.75 60.07,7.13 59.46,7.13 57.44,5.11 53.16,5.11 52.6,4.56 v1(51.84,4.56)
HSEC_SPI1_CS0: length 19.9
  TOP w0.147: J15.81 52.64,5.79 v1(53.44,6.59) ; U8.13 61.91,16.18 v1(61.97,16.12)
  L03_SIG1 w0.091: v1(53.44,6.59) 53.95,6.59 55.04,7.68 56.14,7.68 61.97,13.51 v1(61.97,16.12)
HSEC_SPI1_D0: length 22.4
  TOP w0.147: U8.6 63.21,12.89 v1(64.04,13.72) ; J15.75 v1(50.24,4.56)
  L03_SIG1 w0.091: v1(64.04,13.72) 63.67,13.72 59.75,9.8 59.75,8.9 56.98,6.13 53.2,6.13 52.22,5.15 50.83,5.15 v1(50.24,4.56)
HSEC_SPI1_D1: length 23.8
  TOP w0.147: J15.77 51.04,5.79 v1(51.84,6.59) ; U8.10 v1(63.86,16.13)
  L03_SIG1 w0.091: v1(63.86,16.13) 63.45,16.54 61.79,16.54 61.16,15.91 61.16,13.13 56.14,8.11 54.99,8.11 54.05,7.18 53.42,7.18 52.83,6.59 v1(51.84,6.59)
HSEC_TCK: length 83.3
  TOP w0.147: v1(40.74,59.7) R183.2 40.18,60.34 39.75,60.78 39.75,61.96 39.32,62.39 U30.14 ; J15.5 v1(19.04,4.56)
  L03_SIG1 w0.091: v1(19.04,4.56) 19.73,5.25 19.73,10.05 19.5,10.28 19.5,18.6 24.73,23.83 24.73,31.68 22.26,34.15 22.26,54.49 22.85,55.08 25.12,55.08 31.56,61.52 37.96,61.52 39.78,59.7 v1(40.74,59.7)
HSEC_TDI: length 72.9
  TOP w0.147: U30.5 30.8,61.09 30.54,60.83 R181.2 v1(29.98,61.58)
  L03_SIG1 w0.091: v1(19.04,7.61) 18.37,8.28 18.37,14.23 19.28,15.15 19.28,18.65 24.54,23.91 24.54,31.6 22.07,34.07 22.07,59.55 24.1,61.58 v1(29.98,61.58)
  BOTTOM w0.147: v1(19.04,7.61) 19.84,6.81 J15.8
HSEC_TDO: length 74.2
  TOP w0.147: v1(29.98,63.22) R180.2 30.55,62.43 31.17,63.04 U30.2
  L03_SIG1 w0.091: v1(19.04,5.58) 17.98,6.63 17.98,14.36 18.92,15.3 18.92,18.8 22.16,22.04 22.16,23.9 23.88,25.61 23.88,31.75 21.71,33.92 21.71,59.77 24.44,62.5 27.44,62.5 28.17,63.22 v1(29.98,63.22)
  BOTTOM w0.147: v1(19.04,5.58) 19.49,5.12 19.49,4.37 19.04,3.92 J15.6
HSEC_TMS: length 90.2
  TOP w0.147: J15.3 18.24,5.78 v1(19.05,6.59) ; v1(40.64,58.28) 40.74,58.38 R182.2 39.97,58.95 39.62,59.3 39.62,59.93 39.11,60.44 U30.11
  L03_SIG1 w0.091: v1(19.05,6.59) 18.17,7.47 18.17,14.29 19.1,15.22 19.1,18.72 24.36,23.98 24.36,31.53 21.89,34 21.89,59.63 24.26,62 29.1,62 29.33,62.23 31.3,62.23 31.69,61.83 37.91,61.83 38.64,61.1 40.62,61.1 41.39,60.32 41.39,59.04 v1(40.64,58.28)
HSEC_UART1_RXD: length 117.1
  L08_SIG2 w0.091: v1(27.61,68.48) 26.43,68.48 18.7,60.75 18.7,58.27 14.48,54.05 14.48,38.88 16.84,36.52 16.84,35.3 13.98,32.44 13.41,32.44 12.63,31.65 12.63,27.61 13.33,26.91 13.33,23.3 18.4,18.23 24.43,18.23 24.49,18.17 24.99,18.17 v1(25.65,17.51)
  BOTTOM w0.147: U44.3 v1(27.61,68.48) ; v1(25.65,17.51) 27.45,19.32 47.4,19.32 49.86,16.86 53.18,16.86 53.77,16.26 53.77,15.59 55.09,14.27 55.09,11.4 54.53,10.84 54.53,10.41 50.74,6.63 50.74,4.37 50.24,3.86 J15.76
HSEC_UART1_TXD: length 126.6
  L08_SIG2 w0.091: v1(30.22,70.43) 26.02,70.43 14.17,58.59 14.17,38.85 16.66,36.36 16.66,35.38 13.9,32.62 11.31,32.62 10.27,31.58 10.27,28.09 13.15,25.21 13.15,22.08 17.18,18.05 24.22,18.05 v1(24.76,17.51)
  BOTTOM w0.147: J15.78 51.04,6.5 54.83,10.29 54.83,10.72 55.38,11.28 55.38,14.4 54.07,15.71 54.07,16.39 53.3,17.15 49.98,17.15 47.52,19.61 47.28,19.61 26.86,19.61 v1(24.76,17.51) ; U44.6 v1(30.22,70.43)
HSEC_VREF_3V3: length 5.5
  TOP w0.381: J15.45 35.04,4.24 34.3,4.97 R417.1
I2C0_MUX_OE#: length 2.3
  BOTTOM w0.147: R165.1 40.37,71.56 U26.15
I2C0_MUX_SEL: length 17.1
  TOP w0.147: v1(57.46,66.54) 57.46,67.21 56.51,68.16 55.07,68.16 54.04,69.19 54.04,70.88 52.7,72.22 49.85,72.22 v1(49.04,73.03)
  BOTTOM w0.147: R164.1 R162.2 ; R164.1 v1(49.04,73.03) ; R164.1 48.73,72.25 48.69,72.21 U26.1 ; U60.10 v1(57.46,66.54)
I2C0_SCL: length 109.8
  TOP w0.147: v1(70.99,95.24) 71.44,95.24 71.65,95.44 J8.40
  L03_SIG1 w0.091: v1(46.04,71.56) 46.04,74.36 47.49,75.81 47.49,92.91 50.54,95.95 66.97,95.95 68.12,94.81 70.56,94.81 v1(70.99,95.24)
  L08_SIG2 w0.091: v1(70.99,95.24) 70.99,96.03 75.15,100.2 75.15,102.06 78.9,105.81 81.62,105.81 82.08,106.28 84.91,106.28 86.76,108.12 100.81,108.12 107.05,101.88 107.05,94.12 v1(110.06,91.12)
  BOTTOM w0.147: U26.2 v1(46.04,71.56) ; R154.2 v1(70.99,95.24) ; U28.6 v1(110.06,91.12)
I2C0_SDA: length 114.5
  TOP w0.147: v1(70.23,95.24) 70.83,95.84 J8.42
  L03_SIG1 w0.091: v1(70.23,95.24) 68.02,95.24 67.05,96.21 50.41,96.21 47.2,93.01 47.2,75.87 45.54,74.21 45.54,70.11 v1(46.04,69.61)
  L08_SIG2 w0.091: v1(108.79,91.12) 106.78,93.13 106.78,101.77 100.63,107.92 86.98,107.92 85.05,105.99 82.74,105.99 81.57,104.83 78.22,104.83 75.37,101.97 75.37,100.11 71.69,96.42 71.69,95.23 71.19,94.73 70.73,94.73 v1(70.23,95.24)
  BOTTOM w0.147: v1(70.23,95.24) 70.23,95.69 70.97,96.43 R155.2 ; U26.5 v1(46.04,69.61) ; U28.5 v1(108.79,91.12)
ICSSM0_MUX_SEL: length 122
  TOP w0.147: U87.9 78.76,60.39 v1(79.01,60.64) 78.76,60.89 U87.10 ; v1(59.63,78.54) 59.63,78.91 54.99,83.55 52.57,83.55 51.18,84.94 48.04,84.94 47.31,84.21 SW14.1 R1383.2
  L03_SIG1 w0.091: v1(59.63,78.54) 59.06,78.54 58.65,78.12 58.65,74.01 59.96,72.7 60.52,72.7 60.89,72.33 69.4,72.33 71.34,74.27 v1(72.66,74.27)
  BOTTOM w0.147: v1(79.01,60.64) 77.57,62.09 75.37,62.09 73.92,63.53 73.92,66.13 73.31,66.74 73.31,73.61 v1(72.66,74.27) ; U88.9 82.07,101.77 81.62,101.77 81.49,101.63 81.21,101.63 81.04,101.63 79.16,103.51 76.92,103.51 75.52,102.12 71.84,102.12 70.96,102.99 68.17,102.99 66.77,101.59 66.77,98.45 61.83,93.5 61.83,92.55 62,92.38 62,91.95 61.53,91.48 61.53,91.01 60.7,90.18 60.7,89.13 61.94,87.9 61.94,82.72 63.08,81.58 63.08,80.25 61.37,78.54 v1(59.63,78.54) 58.26,78.54 56.5,76.79 51.84,76.79 51.24,76.18 51.24,72.75 52.7,71.29 52.7,70.5 52.96,70.24 U60.21
ICSSM1_ETH_LED2: length 8.1
  BOTTOM w0.147: Q6.3 105.73,79.95 106.25,79.43 107.62,79.43 J7.12
ICSSM1_INTN: length 59.8
  TOP w0.147: R195.2 56.85,54.27 58.15,55.58 v1(58.15,56.42)
  L08_SIG2 w0.091: v1(58.15,56.42) 58.86,57.12 64.08,57.12 64.85,57.89 65.37,57.89 67.34,55.92 68.85,55.92 69.21,55.56 69.65,55.56 69.94,55.27 69.94,54.86 70.14,54.67 71.17,54.67 71.76,54.09 81.52,54.09 82.98,55.55 86.64,55.55 91.99,60.9 91.99,61.63 89.94,63.68 v1(89.94,73.01)
  BOTTOM w0.147: U35.44 89.95,72.12 89.95,72.99 v1(89.94,73.01) 90.4,73.47 90.4,74.44 90.07,74.77 R214.2
ICSSM1_LED_GREEN: length 7
  TOP w0.147: J7.13 107.82,60.85 R218.2 Q7.3
ICSSM1_LED_YELLOW: length 8.9
  BOTTOM w0.147: Q8.3 109.32,57.55 R219.2 107.82,59.17 108.71,60.06 110.74,60.06 111.3,60.62 J7.14
ICSSM1_MUX_EN1: length 2.7
  TOP w0.147: U87.8 v1(79.93,59.89)
  BOTTOM w0.147: R1381.1 79.97,59.85 v1(79.93,59.89)
ICSSM1_MUX_EN2: length 2.3
  BOTTOM w0.147: U88.8 80.82,101.34 80.5,101.65 R3861.2
ICSSM1_MUX_EN3: length 1.8
  BOTTOM w0.147: R3864.1 81.05,88.35 U89.8
ICSSM1_MUX_SEL: length 81
  TOP w0.147: v1(81.3,102.09) 80.85,101.63 80.85,89.44 v1(81.32,88.97) ; v1(59.13,77.69) 57.91,78.91 57.91,79.82 55.9,81.82 R3873.2 51.4,81.82 50.8,82.42 SW16.1
  L03_SIG1 w0.091: v1(72.66,76.22) 70.7,74.27 61.82,74.27 61.46,73.91 60.14,73.91 59.8,74.24 59.8,77.02 v1(59.13,77.69)
  L08_SIG2 w0.091: v1(81.32,88.97) 82.37,87.92 82.37,84.82 81.99,84.44 81.99,79.92 80.19,78.12 80.19,73.66 78.82,72.28 78.43,72.28 76.31,74.41 76.31,75.61 75.7,76.22 v1(72.66,76.22)
  BOTTOM w0.147: U89.10 81.69,89.35 v1(81.32,88.97) 81.44,88.85 U89.9 ; v1(81.3,102.09) 81.55,102.34 U88.10 ; v1(59.13,77.69) 59.97,76.85 59.97,74.02 60.74,73.24 60.74,72.03 59.46,70.74 U60.3
ICSSM1_RESETN: length 40
  TOP w0.147: U36.4 R220.2 81.71,43.91 79.49,46.14 79.49,50.35 83.77,54.63 83.77,59.26 87.82,63.31 87.82,64.36 89.79,66.32 89.79,70.09 89.27,70.6 89.27,73.12 v1(89.94,73.78)
  BOTTOM w0.147: v1(89.94,73.78) 89.42,73.27 U35.43
ICSSM2_MUX_EN1: length 1.8
  BOTTOM w0.147: U82.8 R3843.1
ICSSM2_MUX_EN2: length 1.6
  TOP w0.147: U85.8 R3852.1
ICSSM2_MUX_EN3: length 1.6
  TOP w0.147: U84.8 R3849.1
ICSSM2_MUX_SEL: length 117.1
  TOP w0.147: U85.9 93.89,101.84 v1(94.14,102.09) 93.89,102.34 U85.10 ; 94.14,89.1 95.2,89.1 v1(96.37,90.27) ; 94.14,89.1 93.89,89.35 U84.10 ; 94.14,89.1 93.89,88.85 U84.9 ; v1(60.44,74.36) 59.14,73.07 59.14,70.87 60.15,69.85 60.15,68.57 60.65,68.07 60.65,66.79 60.02,66.17 60.02,63.95 61.19,62.78 61.82,62.78 62.34,63.3 R3844.2 SW15.1 64.24,61.72 65.32,60.64 v1(66.18,60.64)
  L03_SIG1 w0.091: v1(60.44,74.36) 62.45,76.38 62.45,79.2 65.48,82.24 69.52,82.24 69.92,82.64 69.92,83.14 71.85,85.06 71.85,85.68 72.86,86.69 73.83,86.69 73.85,86.68 73.98,86.68 75.11,87.81 75.11,99.92 78.05,102.87 78.05,104.05 81.63,107.63 84.31,107.63 84.55,107.38 84.55,106.84 84.73,106.66 85.62,106.66 85.8,106.84 87.26,106.84 88.58,105.53 88.58,105.1 88.78,104.9 89.58,104.9 90.14,104.33 90.14,103.86 90.38,103.62 92.6,103.62 v1(94.14,102.09)
  BOTTOM w0.147: U60.4 59.69,70.24 61.2,71.76 61.2,73.6 v1(60.44,74.36) ; v1(96.37,90.27) 97.37,91.28 100.35,91.28 101.13,92.05 101.13,99.8 100.06,100.86 95.36,100.86 v1(94.14,102.09) ; U82.10 66.43,60.89 v1(66.18,60.64) 66.43,60.39 U82.9
ICSSM2_PWDN/INTN: length 84.3
  TOP w0.147: v1(70.34,90.9) R267.1 70.89,90.14 71.59,89.44 J8.10
  L08_SIG2 w0.091: v1(70.34,90.9) 70.34,90.06 70.92,89.47 70.92,88.44 67.81,85.33 67.3,85.33 66.44,84.47 66.44,82.47 67.03,81.88 67.03,78.74 66.84,78.55 66.84,77.39 65.62,76.17 65.62,64.43 63.61,62.42 61,62.42 60.51,62.91 59.4,62.91 56.89,60.4 53.33,60.4 50.22,63.51 49.34,63.51 49.15,63.33 43.13,63.33 41.8,62 41.8,58.84 44.28,56.36 44.28,51.82 42.65,50.19 42.65,48.55 44.34,46.86 46.04,46.86 47.16,45.75 47.16,45.06 47.35,44.86 47.35,44.53 v1(47.13,44.31)
  BOTTOM w0.147: v1(47.13,44.31) 47.64,44.31 47.79,44.16 R191.2
ICSSM2_RESETN: length 24.1
  TOP w0.147: J8.12 71.71,89.84 71.04,90.51 71.04,91.06 70.72,91.38 69.18,91.38 68.54,92.01 68.54,94.32 67.99,94.87 67.99,98.56 68.76,99.33 75.42,99.33 v1(76.53,100.44)
  BOTTOM w0.147: U39.4 R266.2 77.26,100.71 76.99,100.44 v1(76.53,100.44)
ICSSM_BRD_CONN_DET: length 2.4
  TOP w0.147: J8.36 71.92,94.64 70.99,93.71 R263.1
ICSSM_INH: length 2
  TOP w0.147: R264.2 71.04,92.68 71.13,92.77 71.8,92.77 71.92,92.64 J8.26
ICSSM_MII0/MII1_COL_ADD: length 11
  TOP w0.147: R509.2 v1(72.05,84.11) ; v1(74.28,89.86) 73.84,90.3 73.09,90.3 73.03,90.24 J8.14
  BOTTOM w0.147: R509.2 v1(72.05,84.11) 72.69,84.76 73.77,84.76 74.8,85.79 74.8,89.33 v1(74.28,89.86)
ICSSM_MII0/MII1_COL_ON: length 2.2
  TOP w0.147: R493.2 v1(99.76,96.93) TP83.1
  BOTTOM w0.147: R493.2 v1(99.76,96.93)
ICSSM_MII0/MII1_CRS_ADD: length 12.8
  TOP w0.147: R510.2 70.43,84.66 70.57,84.8 v1(70.88,84.8) ; J8.30 v1(71.53,93.44)
  BOTTOM w0.147: v1(71.53,93.44) 72.56,92.42 72.56,86.48 v1(70.88,84.8) 70.57,84.8 70.43,84.66 R510.2
ICSSM_MII0/MII1_CRS_ON: length 2.2
  TOP w0.147: R494.2 v1(99.76,97.92) TP84.1
  BOTTOM w0.147: R494.2 v1(99.76,97.92)
ICSSM_MII0/MII1_RXCLK_ADD: length 35.1
  TOP w0.147: R531.2 v1(75.44,67.69) ; J8.19 v1(75.93,91.44)
  BOTTOM w0.147: v1(75.93,91.44) 76.38,91.9 76.38,92.82 76.58,93.02 76.97,93.02 77.48,93.52 77.75,93.52 78.05,93.22 78.05,92.87 75.8,90.62 75.8,84.43 77.59,82.64 77.59,80.13 74.29,76.83 74.29,68.84 v1(75.44,67.69) R531.2
ICSSM_MII0/MII1_RXCLK_ON: length 64.4
  TOP w0.147: R483.2 v1(99.89,92.95)
  L08_SIG2 w0.091: v1(99.89,92.95) 100.32,92.52 100.32,90.08 100.44,89.96 100.75,89.96 100.9,90.11 100.9,93.99 100.79,94.1 100.51,94.1 100.4,94.21 100.4,94.36 100.51,94.46 100.79,94.46 100.9,94.57 100.9,94.72 100.79,94.83 100.51,94.83 100.4,94.94 100.4,95.09 100.51,95.2 100.79,95.2 100.9,95.3 100.9,95.45 100.79,95.56 100.51,95.56 100.4,95.67 100.4,95.82 100.51,95.93 100.79,95.93 100.9,96.03 100.9,96.19 100.79,96.29 100.51,96.29 100.4,96.4 100.4,96.55 100.51,96.66 100.79,96.66 100.9,96.77 100.9,96.92 100.79,97.02 100.51,97.02 100.4,97.13 100.4,97.28 100.51,97.39 100.79,97.39 100.9,97.5 100.9,97.86 101.07,98.03 101.39,98.03 101.56,97.85 101.56,89.87 100.65,88.95 100.63,88.95 100.63,88.03 99.66,87.06 99.66,83.74 96.32,80.4 90.41,80.4 87.48,77.46 87.48,75.88 86,74.4 86,68.77 84.97,67.75 84.04,67.75 83.69,68.09 83.69,70 83.34,70.36 82.51,70.36 v1(81.94,69.79)
  BOTTOM w0.147: R212.1 82.12,69.96 v1(81.94,69.79) ; R483.2 v1(99.89,92.95)
ICSSM_MII0/MII1_RXD0_ADD: length 35.1
  TOP w0.147: R533.2 v1(78.21,73.64) ; J8.23 75.54,92.24 75.76,92.02 76.35,92.02 v1(76.84,92.52)
  L08_SIG2 w0.091: v1(78.21,73.64) 78.04,73.8 77.95,73.8 77.64,74.11 77.38,74.11 76.82,74.68 76.82,75.92 75.76,76.98 75.76,78.42 77.66,80.33 77.66,87.77 77.55,87.87 76.57,87.87 76.47,87.98 76.47,88.13 76.57,88.24 77.55,88.24 77.66,88.35 77.66,88.5 77.55,88.6 76.57,88.6 76.47,88.71 76.47,88.86 76.57,88.97 77.55,88.97 77.66,89.08 77.66,89.23 77.55,89.34 76.57,89.34 76.47,89.44 76.47,89.59 76.57,89.7 77.55,89.7 77.66,89.81 77.66,89.96 77.55,90.07 76.57,90.07 76.47,90.17 76.47,90.33 76.57,90.43 77.55,90.43 77.66,90.54 77.66,90.69 77.55,90.8 76.57,90.8 76.47,90.91 76.47,91.06 76.57,91.16 77.55,91.16 77.66,91.27 77.66,91.69 v1(76.84,92.52)
  BOTTOM w0.147: v1(78.21,73.64) 77.6,73.64 R525.2
ICSSM_MII0/MII1_RXD0_ON: length 66.6
  TOP w0.147: R225.2 83.87,69.84 v1(84.58,69.84) 85.48,69.84 R237.1 ; R476.2 v1(82.53,82.11)
  L03_SIG1 w0.091: v1(82.53,82.11) 80.17,82.11 79.77,81.71 79.77,74.6 78.38,73.21 77.28,73.21 77.17,73.1 77.17,71.4 77.06,71.29 76.91,71.29 76.8,71.4 76.8,73.1 76.7,73.21 76.13,73.21 75.79,72.86 75.79,71.38 75.57,71.16 74.38,71.16 71.15,67.93 71.15,67.51 68.8,65.16 68.8,64.73 69.15,64.38 69.48,64.38 69.81,64.7 69.81,64.85 69.54,65.12 69.54,65.27 69.65,65.38 69.8,65.38 70.07,65.11 70.22,65.11 70.33,65.22 70.33,65.37 70.06,65.64 70.06,65.79 70.17,65.9 70.32,65.9 70.59,65.63 70.74,65.63 70.84,65.74 70.84,65.89 70.58,66.16 70.58,66.31 70.68,66.41 70.84,66.41 71.1,66.15 71.25,66.15 71.36,66.25 71.36,66.41 71.09,66.67 71.09,66.82 71.2,66.93 71.35,66.93 71.62,66.66 71.77,66.66 72.81,67.71 72.81,67.86 72.33,68.34 72.33,68.49 72.44,68.6 72.59,68.6 73.07,68.12 73.23,68.12 73.33,68.22 73.33,68.38 72.85,68.86 72.85,69.01 72.96,69.12 73.11,69.12 73.59,68.63 73.74,68.63 73.85,68.74 73.85,68.89 73.37,69.38 73.37,69.53 73.47,69.63 73.63,69.63 74.11,69.15 74.26,69.15 74.37,69.26 74.37,69.41 73.89,69.89 73.89,70.04 73.99,70.15 74.14,70.15 74.63,69.67 74.78,69.67 75.25,70.15 76.69,70.15 77.71,71.17 77.71,71.8 78.01,72.1 78.72,72.1 80.27,70.54 80.27,68.67 80.61,68.33 83.07,68.33 v1(84.58,69.84)
  BOTTOM w0.147: U35.33 v1(84.58,69.84) ; R476.2 v1(82.53,82.11)
ICSSM_MII0/MII1_RXD1_ADD: length 35.3
  TOP w0.147: J8.25 75.8,92.64 v1(75.93,92.52) ; R534.2 78.42,72.64 78.5,72.72 v1(78.63,72.72)
  L08_SIG2 w0.091: v1(75.93,92.52) 75.24,92.52 74.89,92.17 74.89,90.55 75,90.44 75.81,90.44 75.92,90.33 75.92,90.18 75.81,90.07 75,90.07 74.89,89.97 74.89,89.82 75,89.71 75.81,89.71 75.92,89.6 75.92,89.45 75.81,89.34 75,89.34 74.89,89.24 74.89,89.08 75,88.98 75.81,88.98 75.92,88.87 75.92,88.72 75.81,88.61 75,88.61 74.89,88.5 74.89,88.35 75,88.25 75.81,88.25 75.92,88.14 75.92,87.99 75.81,87.88 75,87.88 74.89,87.77 74.89,87.53 75,87.42 77.15,87.42 77.36,87.21 77.36,80.35 75.5,78.49 75.5,76.84 76.59,75.75 76.59,74.57 78.44,72.72 v1(78.63,72.72)
  BOTTOM w0.147: v1(78.63,72.72) 78.5,72.72 78.42,72.64 R534.2
ICSSM_MII0/MII1_RXD1_ON: length 66.8
  TOP w0.147: v1(83.02,80.48) 83.11,80.57 R477.2 ; R226.2 84.45,70.98 v1(84.58,70.85) 84.7,70.98 R238.1
  L03_SIG1 w0.091: v1(83.02,80.48) 83.72,80.48 84.02,80.78 84.02,81.51 83.42,82.12 83.22,82.12 82.79,81.68 80.19,81.68 80.05,81.54 80.05,81.24 80.13,81.16 81.27,81.16 81.35,81.08 81.35,80.97 81.27,80.89 80.13,80.89 80.05,80.81 80.05,80.69 80.13,80.61 81.27,80.61 81.35,80.53 81.35,80.42 81.27,80.34 80.13,80.34 80.05,80.26 80.05,80.14 80.13,80.06 81.27,80.06 81.35,79.98 81.35,79.87 81.27,79.79 80.13,79.79 80.05,79.71 80.05,79.6 80.13,79.52 81.27,79.52 81.35,79.43 81.35,79.32 81.27,79.24 80.13,79.24 80.05,79.16 80.05,79.05 80.13,78.97 81.27,78.97 81.35,78.89 81.35,78.77 81.27,78.69 80.13,78.69 80.05,78.61 80.05,78.5 80.13,78.42 81.27,78.42 81.35,78.34 81.35,78.22 81.27,78.14 80.13,78.14 80.05,78.06 80.05,77.95 80.13,77.87 81.27,77.87 81.35,77.79 81.35,77.68 81.27,77.6 80.13,77.6 80.05,77.51 80.05,77.4 80.13,77.32 81.27,77.32 81.35,77.24 81.35,77.13 81.27,77.05 80.13,77.05 80.05,76.97 80.05,76.85 80.13,76.77 81.27,76.77 81.35,76.69 81.35,76.58 81.27,76.5 80.13,76.5 80.05,76.42 80.05,76.3 80.13,76.22 81.27,76.22 81.35,76.14 81.35,76.03 81.27,75.95 80.13,75.95 80.05,75.87 80.05,75.76 80.13,75.67 81.27,75.67 81.35,75.59 81.35,75.48 81.27,75.4 80.13,75.4 80.05,75.32 80.05,75.21 80.13,75.13 81.27,75.13 81.35,75.05 81.35,74.93 81.27,74.85 80.13,74.85 80.05,74.77 80.05,74.66 80.13,74.58 81.27,74.58 81.35,74.5 81.35,74.38 81.27,74.3 80.13,74.3 80.05,74.22 80.05,73.97 80.16,73.87 80.6,73.87 80.7,73.77 80.7,73.61 80.59,73.5 79.29,73.5 79.16,73.38 79.16,73.23 79.26,73.13 80.48,73.13 80.59,73.03 80.59,72.88 80.48,72.77 79.29,72.77 79.16,72.64 79.16,72.49 79.26,72.4 80.48,72.4 80.59,72.3 80.59,72.14 80.48,72.04 79.74,72.04 79.65,71.94 79.65,71.55 80.55,70.66 80.55,69.06 80.86,68.75 81.27,68.75 81.81,69.3 83.41,69.3 84.58,70.46 v1(84.58,70.85)
  BOTTOM w0.147: R477.2 83.11,80.57 v1(83.02,80.48) ; v1(84.58,70.85) 84.58,70.73 84.96,70.34 U35.34
ICSSM_MII0/MII1_RXD2_ADD: length 35
  TOP w0.147: J8.27 76.15,93.04 76.4,93.29 76.4,93.91 76.6,94.11 77.3,94.11 77.42,93.99 77.42,93.78 77.31,93.67 76.98,93.67 76.81,93.5 76.81,93.22 77.3,92.73 77.31,92.73 77.31,92.13 77.13,91.96 76.86,91.96 76.68,91.79 76.68,91.54 77.2,91.03 77.2,90.12 77.33,89.99 77.44,89.99 77.57,89.87 77.57,89.68 77.44,89.55 77.33,89.55 77.2,89.42 77.2,89.24 77.33,89.11 77.44,89.11 77.57,88.98 77.57,88.8 77.44,88.67 77.33,88.67 77.2,88.54 77.2,88.36 77.33,88.23 77.44,88.23 77.57,88.1 77.57,87.91 77.44,87.78 77.33,87.78 77.2,87.66 77.2,87.47 77.33,87.34 77.44,87.34 77.57,87.21 77.57,87.03 77.44,86.9 77.33,86.9 77.2,86.77 77.2,86.59 77.33,86.46 77.44,86.46 77.57,86.33 77.57,86.15 77.44,86.02 77.33,86.02 77.2,85.89 77.2,85.7 77.33,85.57 77.44,85.57 77.57,85.45 77.57,85.26 77.44,85.13 77.33,85.13 77.2,85 77.2,84.59 77.45,84.34 77.63,84.34 77.76,84.47 77.94,84.47 78.07,84.34 78.07,84.16 77.94,84.03 77.94,83.84 78.64,83.14 78.64,78.78 79.08,78.34 79.08,77.49 78.95,77.36 78.74,77.36 78.61,77.23 78.61,77.05 78.74,76.92 78.95,76.92 79.08,76.79 79.08,76.56 78.95,76.43 78.76,76.43 78.63,76.3 78.63,76.12 78.76,75.99 78.95,75.99 79.08,75.86 79.08,75.46 78.95,75.33 78.76,75.33 78.63,75.2 78.63,75.02 78.76,74.89 78.95,74.89 79.08,74.76 79.08,74.39 78.95,74.26 78.7,74.26 78.57,74.13 78.57,73.95 78.7,73.82 78.95,73.82 79.08,73.69 79.08,72.37 78.37,71.66 v1(78.2,71.66) 78.2,71.65 R535.2
  BOTTOM w0.147: v1(78.2,71.66) 78.2,71.65 R535.2
ICSSM_MII0/MII1_RXD2_ON: length 67.2
  TOP w0.147: R243.2 84.83,72.12 v1(84.58,71.87) 84.32,72.13 R231.1 ; R479.2 83.44,79.43 83.22,79.21 v1(83.22,78.55)
  L03_SIG1 w0.091: v1(84.58,71.87) 84.18,71.48 83.31,71.48 83.23,71.4 83.23,71.28 83.31,71.2 83.97,71.2 84.05,71.12 84.05,71.01 83.97,70.93 83.31,70.93 83.23,70.85 83.23,70.73 83.31,70.65 83.97,70.65 84.05,70.57 84.05,70.41 83.89,70.25 82.74,70.25 82.66,70.17 82.66,69.72 82.58,69.64 82.46,69.64 82.38,69.72 82.38,70.17 82.3,70.25 81.63,70.25 81.42,70.04 81.42,69.29 81.25,69.12 81.02,69.12 80.9,69.25 80.9,70.46 80.98,70.54 82.8,70.54 82.89,70.62 82.89,70.73 82.8,70.81 80.98,70.81 80.9,70.89 80.9,71.01 80.98,71.09 82.8,71.09 82.89,71.17 82.89,71.28 82.8,71.36 80.98,71.36 80.9,71.44 80.9,71.56 80.98,71.64 82.8,71.64 82.89,71.72 82.89,71.83 82.8,71.91 80.98,71.91 80.9,71.99 80.9,72.11 80.98,72.19 82.8,72.19 82.89,72.27 82.89,72.38 82.8,72.46 80.98,72.46 80.9,72.54 80.9,72.65 80.98,72.73 82.8,72.73 82.89,72.81 82.89,72.93 82.8,73.01 81.16,73.01 81.01,73.17 81.01,73.78 81.18,73.96 81.47,73.96 81.63,74.11 81.63,74.45 81.71,74.54 82.12,74.54 82.2,74.62 82.2,74.73 82.12,74.81 81.71,74.81 81.63,74.89 81.63,75 81.71,75.08 82.12,75.08 82.2,75.16 82.2,75.28 82.12,75.36 81.71,75.36 81.63,75.44 81.63,75.55 81.71,75.63 82.12,75.63 82.2,75.71 82.2,75.83 82.12,75.91 81.71,75.91 81.63,75.99 81.63,76.1 81.71,76.18 82.12,76.18 82.2,76.26 82.2,76.38 82.12,76.46 81.71,76.46 81.63,76.54 81.63,76.65 81.71,76.73 82.12,76.73 82.2,76.81 82.2,76.92 82.12,77 81.71,77 81.63,77.08 81.63,77.2 81.71,77.28 82.12,77.28 82.2,77.36 82.2,77.47 82.12,77.55 81.71,77.55 81.63,77.63 81.63,77.75 81.71,77.83 82.12,77.83 82.2,77.91 82.2,78.02 82.12,78.1 81.71,78.1 81.63,78.18 81.63,78.3 81.71,78.38 82.12,78.38 82.2,78.46 82.2,78.57 82.12,78.65 81.71,78.65 81.63,78.73 81.63,78.84 81.71,78.92 82.12,78.92 82.2,79 82.2,79.12 82.12,79.2 81.71,79.2 81.63,79.28 81.63,79.39 81.71,79.47 82.12,79.47 82.2,79.55 82.2,79.67 82.12,79.75 81.71,79.75 81.63,79.83 81.63,79.94 81.71,80.02 82.12,80.02 82.2,80.1 82.2,80.22 82.12,80.3 81.71,80.3 81.63,80.38 81.63,80.49 81.71,80.57 82.12,80.57 82.2,80.65 82.2,80.76 82.12,80.84 81.71,80.84 81.63,80.92 81.63,81.2 81.83,81.41 82.91,81.41 83.25,81.74 83.41,81.74 83.75,81.4 83.75,80.96 83.69,80.91 82.85,80.91 82.6,80.66 82.6,80.08 82.76,79.91 83.16,79.91 83.4,80.15 83.82,80.15 84.04,79.94 84.04,78.74 83.84,78.55 v1(83.22,78.55)
  BOTTOM w0.147: v1(84.58,71.87) 84.96,71.48 84.96,71.1 85.22,70.84 U35.35 ; v1(83.22,78.55) 83.79,79.11 R479.2
ICSSM_MII0/MII1_RXD3_ADD: length 35.4
  TOP w0.147: R536.2 77.6,70.67 v1(78.69,70.67) 78.69,71.47 79.43,72.22 79.43,78.48 78.99,78.92 78.99,83.56 78.84,83.71 78.69,83.71 78.56,83.84 78.56,84.03 78.69,84.16 78.84,84.16 78.99,84.31 78.99,84.52 78.64,84.87 78.46,84.87 78.35,84.76 78.16,84.76 78.03,84.89 78.03,85.08 78.14,85.19 78.14,85.37 77.92,85.59 77.92,90.22 77.79,90.35 77.67,90.35 77.54,90.48 77.54,90.66 77.67,90.79 77.79,90.79 77.92,90.92 77.92,91.1 77.79,91.23 77.67,91.23 77.54,91.36 77.54,91.54 77.67,91.67 77.79,91.67 77.92,91.8 77.92,92.87 77.79,93 77.67,93 77.54,93.13 77.54,93.31 77.67,93.44 77.79,93.44 77.92,93.57 77.92,94.17 77.6,94.49 77.6,95.54 77.45,95.68 77.24,95.68 77.07,95.51 76.73,95.51 76.6,95.38 76.6,95.2 76.73,95.07 76.89,95.07 77.03,94.92 77.03,94.64 76.85,94.46 76.35,94.46 75.98,94.08 75.98,93.62 75.8,93.44 J8.29
  BOTTOM w0.147: R536.2 77.6,70.67 v1(78.69,70.67)
ICSSM_MII0/MII1_RXD3_ON: length 66.8
  TOP w0.147: R232.1 84.07,73.27 v1(84.58,72.76) 85.09,73.27 R244.2 ; v1(83.83,77.57) 84.07,77.81 R480.2
  L03_SIG1 w0.091: v1(83.83,77.57) 84.69,77.57 85.25,78.14 85.25,78.44 85.07,78.62 84.31,78.62 83.81,78.12 83.04,78.12 82.79,78.37 82.79,78.94 83,79.15 83.61,79.15 83.76,79.3 83.76,79.49 83.62,79.64 82.74,79.64 82.49,79.38 82.49,77.79 82.57,77.7 83.34,77.7 83.42,77.62 83.42,77.51 83.34,77.43 82.57,77.43 82.49,77.35 82.49,77.24 82.57,77.16 84.04,77.16 84.12,77.08 84.12,76.96 84.04,76.88 82.57,76.88 82.49,76.8 82.49,76.69 82.57,76.61 84.04,76.61 84.12,76.53 84.12,76.41 84.04,76.33 82.57,76.33 82.49,76.25 82.49,76.14 82.57,76.06 84.04,76.06 84.12,75.98 84.12,75.86 84.04,75.78 82.57,75.78 82.49,75.7 82.49,75.59 82.57,75.51 84.04,75.51 84.12,75.43 84.12,75.32 84.04,75.24 82.57,75.24 82.49,75.16 82.49,75.04 82.57,74.96 84.04,74.96 84.12,74.88 84.12,74.77 84.04,74.69 83.87,74.69 83.79,74.61 83.79,73.94 83.71,73.86 83.59,73.86 83.51,73.94 83.51,74.61 83.43,74.69 83.32,74.69 83.24,74.61 83.24,73.94 83.16,73.86 83.04,73.86 82.96,73.94 82.96,74.61 82.88,74.69 82.57,74.69 82.49,74.61 82.49,74.39 82.35,74.26 82.05,74.26 81.91,74.13 81.91,73.37 82.01,73.28 82.92,73.28 82.95,73.25 82.96,73.25 83.17,73.03 83.17,71.85 83.28,71.75 84,71.75 84.15,71.91 84.15,72.05 84.4,72.3 84.79,72.3 85.05,72.04 85.05,68.75 85.2,68.6 85.55,68.6 85.81,68.87 85.81,69.09 85.73,69.17 85.43,69.17 85.35,69.25 85.35,69.36 85.43,69.44 85.73,69.44 85.81,69.52 85.81,69.64 85.73,69.72 85.43,69.72 85.35,69.8 85.35,69.91 85.43,69.99 85.73,69.99 85.81,70.07 85.81,70.18 85.73,70.26 85.43,70.26 85.35,70.34 85.35,70.46 85.43,70.54 85.73,70.54 85.81,70.62 85.81,70.85 86.25,71.28 86.25,71.63 86.17,71.71 85.51,71.71 85.43,71.79 85.43,71.9 85.51,71.98 86.17,71.98 86.25,72.06 86.25,72.18 86.17,72.26 85.51,72.26 85.43,72.34 85.43,72.45 85.51,72.53 86.17,72.53 86.25,72.61 86.25,72.73 86.17,72.81 85.51,72.81 85.43,72.89 85.43,73 85.51,73.08 86.17,73.08 86.25,73.16 86.25,73.52 85.78,73.98 85.44,73.98 85.34,74.08 85.34,74.76 85.24,74.86 85.11,74.86 85.01,74.76 85.01,74.08 84.92,73.98 84.26,73.98 83.92,73.65 83.92,73.01 84.18,72.76 v1(84.58,72.76)
  BOTTOM w0.147: v1(83.83,77.57) 84.46,77.57 84.73,77.84 R488.2 ; v1(84.58,72.76) 85.67,71.66 U35.36
ICSSM_MII0/MII1_RXDV_ADD: length 35.4
  TOP w0.147: R529.2 v1(75.44,69.67) ; J8.45 75.84,96.64 76.24,97.04 v1(76.89,97.04)
  BOTTOM w0.147: R529.2 v1(75.44,69.67) 74.87,70.23 74.87,76.58 78.24,79.95 78.24,82.83 76.5,84.56 76.5,90.49 78.89,92.88 78.89,93.88 78.38,94.39 77.79,94.39 77.5,94.68 77.5,96.43 v1(76.89,97.04)
ICSSM_MII0/MII1_RXDV_ON: length 66.7
  TOP w0.147: R242.1 85.23,74.41 v1(84.58,74.41) R230.1 ; R481.2 v1(99.85,94.93)
  L08_SIG2 w0.091: v1(99.85,94.93) 100.21,95.3 100.21,98.3 100.07,98.44 99.47,98.44 99.3,98.27 99.3,91.32 99.56,91.06 99.56,88.83 98.24,87.51 98.24,87.22 98.35,87.11 99.2,87.11 99.31,87 99.31,86.85 99.21,86.74 98.35,86.74 98.24,86.64 98.24,86.48 98.35,86.38 99.2,86.38 99.31,86.27 99.31,86.11 99.21,86.01 98.35,86.01 98.24,85.9 98.24,84.68 98.35,84.57 99.24,84.57 99.35,84.46 99.35,84.31 99.24,84.2 98.35,84.2 98.24,84.1 98.24,83.59 97.75,83.1 97.75,82.95 98.03,82.67 98.03,82.52 97.92,82.41 97.77,82.41 97.49,82.69 97.34,82.69 97.23,82.58 97.23,82.43 97.51,82.15 97.51,82 97.4,81.9 97.25,81.9 96.97,82.17 96.82,82.17 96.72,82.07 96.72,81.91 96.99,81.64 96.99,81.49 96.89,81.38 96.73,81.38 96.46,81.66 96.31,81.66 95.26,80.61 90.35,80.61 87.24,77.5 87.24,75.97 85.73,74.46 85.73,68.97 85.47,68.71 85.14,68.71 84.51,69.34 84.15,69.34 83.96,69.53 83.96,70.07 84.21,70.33 84.95,70.33 85.18,70.57 85.18,74.18 84.95,74.41 v1(84.58,74.41)
  BOTTOM w0.147: R481.2 v1(99.85,94.93) ; U35.38 86.92,72.79 85.3,74.41 v1(84.58,74.41)
ICSSM_MII0/MII1_RXER_ADD: length 35.3
  TOP w0.147: J8.39 76.2,95.44 v1(76.89,96.13) ; R530.2 v1(75.44,68.68)
  BOTTOM w0.147: R530.2 v1(75.44,68.68) 74.58,69.54 74.58,76.71 77.91,80.04 77.91,82.73 76.15,84.49 76.15,90.55 78.43,92.83 78.43,93.55 78.01,93.98 77.6,93.98 77.09,94.49 77.09,95.63 76.89,95.83 v1(76.89,96.13)
ICSSM_MII0/MII1_RXER_ON: length 64.8
  TOP w0.147: v1(99.85,93.94) R482.2 99.07,93.61 98.9,93.44 97.34,93.44 97.16,93.25 97.16,91.78 97.86,91.08 98.22,91.08 98.66,90.64 98.66,89.94 98.29,89.56 97.87,89.56 96.74,88.43 96.74,85.19 91.15,79.59 v1(91.15,77.36)
  L08_SIG2 w0.091: v1(113.02,56.88) 111.03,58.88 109.32,58.88 109.03,58.59 102.42,58.59 99.82,61.19 98.16,61.19 96.31,63.04 96.31,73.54 95.56,74.3 94.21,74.3 v1(91.15,77.36)
  BOTTOM w0.147: R213.2 91.31,75.36 R240.1 R228.2 91.47,77.04 v1(91.15,77.36) ; R482.2 v1(99.85,93.94) ; R223.1 v1(113.02,56.88)
ICSSM_MII0/MII1_RXLINK_ADD: length 35.3
  TOP w0.147: v1(75.98,96.13) 75.86,96.24 J8.43 ; R532.2 v1(75.44,66.7)
  BOTTOM w0.147: R532.2 v1(75.44,66.7) 73.99,68.14 73.99,76.95 77.26,80.22 77.26,82.55 75.42,84.4 75.42,92.81 76.58,93.97 76.58,95.1 75.98,95.7 v1(75.98,96.13)
ICSSM_MII0/MII1_RXLINK_ON: length 66.7
  TOP w0.147: R222.1 v1(113,54.19) ; v1(95.1,73.79) 96.33,73.79 96.97,74.44 96.97,77.11 94.58,79.5 94.58,81.31 97.43,84.16 97.43,85.38 99.07,87.03 99.07,88.27 99.6,88.79 99.6,90.58 99.07,91.1 R484.2 v1(99.89,91.96)
  L08_SIG2 w0.091: v1(113,54.19) 111.34,55.85 108.78,55.85 107.75,54.81 98.06,54.81 95.96,56.91 95.96,65.72 95.1,66.57 v1(95.1,73.79)
  BOTTOM w0.147: R484.2 v1(99.89,91.96) ; v1(95.1,73.79) R227.2 R239.1 92.54,73.79 91.42,72.68 U35.47
ICSSM_MII0/MII1_TXCLK_ADD: length 18.5
  TOP w0.147: R512.2 68.45,84.78 v1(69.08,85.41) 68.26,86.23 68.26,88.5 68.43,88.67 68.67,88.67 68.82,88.52 68.82,86.99 69.8,86.01 75.32,86.01 75.72,86.41 75.72,88.06 75.54,88.24 J8.3
  BOTTOM w0.147: v1(69.08,85.41) 69.08,84.77 68.45,84.13 R512.2
ICSSM_MII0/MII1_TXCLK_ON: length 54.4
  TOP w0.147: R496.2 v1(99.76,98.91)
  L08_SIG2 w0.091: v1(82.69,66.92) 82.69,69.91 82.85,70.06 83.17,70.06 83.36,69.88 83.36,67.86 84.38,66.84 84.78,66.84 86.29,68.35 86.29,73.4 87.89,75.01 87.89,75.71 88.55,76.37 88.55,78.25 90.5,80.2 96.4,80.2 100.56,84.36 100.56,87.48 101.83,88.75 101.83,98.42 101.35,98.91 v1(99.76,98.91)
  BOTTOM w0.147: R210.1 v1(82.69,66.92) ; R496.2 v1(99.76,98.91)
ICSSM_MII0/MII1_TXD0_ADD: length 17.9
  TOP w0.147: J8.7 75.67,89.04 76.02,88.7 76.02,83.78 77.24,82.56 77.24,80.18 75.04,77.98 75.04,75.19 v1(75.58,74.65) R513.2
  BOTTOM w0.147: v1(75.58,74.65) R513.2
ICSSM_MII0/MII1_TXD0_ON: length 56.8
  TOP w0.147: R497.2 v1(100.52,103.03)
  L08_SIG2 w0.091: v1(100.52,103.03) 100.97,103.03 102.12,101.87 102.12,88.54 100.85,87.28 100.85,86.17 101.58,85.44 101.58,84.95 95.92,79.29 94.24,79.29 93.88,79.65 90.22,79.65 88.81,78.24 88.81,76.23 88.14,75.56 88.14,74.77 86.56,73.19 86.56,68.19 v1(83.26,64.88)
  BOTTOM w0.147: U35.28 85.24,67.34 84.2,66.3 84.2,65.5 83.9,65.21 83.58,65.21 v1(83.26,64.88) ; R497.2 v1(100.52,103.03)
ICSSM_MII0/MII1_TXD1_ADD: length 17.7
  TOP w0.147: J8.9 75.74,89.44 76.31,88.87 76.31,83.99 77.59,82.71 77.59,80.03 75.35,77.79 75.35,77.13 75.68,76.81 75.68,76.53 75.35,76.2 75.35,75.91 v1(75.58,75.68) R514.2
  BOTTOM w0.147: R514.2 v1(75.58,75.68)
ICSSM_MII0/MII1_TXD1_ON: length 57.1
  TOP w0.147: R498.2 v1(100.52,104.02)
  L08_SIG2 w0.091: v1(100.52,104.02) 102.4,102.15 102.4,88.49 101.13,87.22 101.13,86.28 101.86,85.55 101.86,84.84 96.02,79 94.14,79 93.77,79.37 90.22,79.37 89.08,78.24 89.08,76.1 88.43,75.45 88.43,74.59 86.87,73.04 86.87,67.47 v1(84.02,64.63)
  BOTTOM w0.147: R498.2 v1(100.52,104.02) ; v1(84.02,64.63) 84.58,65.18 84.58,66.27 85.15,66.84 U35.27
ICSSM_MII0/MII1_TXD2_ADD: length 17.7
  TOP w0.147: R515.2 v1(76.21,77.22) 75.89,77.22 75.76,77.35 75.76,77.71 77.94,79.89 77.94,82.85 76.61,84.19 76.61,90.14 76.46,90.29 76.13,90.29 75.69,89.84 J8.11
  BOTTOM w0.147: R523.2 76.21,77.22 v1(76.21,77.22)
ICSSM_MII0/MII1_TXD2_ON: length 57.2
  TOP w0.147: R499.2 v1(100.52,105.01)
  L08_SIG2 w0.091: v1(84.8,64.64) 87.18,67.03 87.18,72.91 88.74,74.46 88.74,75.39 89.37,76.01 89.37,78.25 90.2,79.08 93.64,79.08 94.02,78.71 96.14,78.71 102.15,84.71 102.15,85.67 101.42,86.4 101.42,87.17 102.69,88.43 102.69,102.84 v1(100.52,105.01)
  BOTTOM w0.147: U35.26 85.18,66.34 84.91,66.07 84.91,65.14 84.86,65.08 84.86,64.7 v1(84.8,64.64) ; R499.2 v1(100.52,105.01)
ICSSM_MII0/MII1_TXD3_ADD: length 18
  TOP w0.147: J8.13 75.59,90.24 75.83,90.48 75.83,90.71 76.18,91.06 76.58,91.06 76.9,90.74 76.9,84.39 78.29,83 78.29,79.07 78.13,78.91 77.63,78.91 77.46,78.74 v1(77.46,78.51) 77.44,78.51 76.95,78.02 R516.2
  BOTTOM w0.147: R516.2 76.95,78.18 77.27,78.51 v1(77.46,78.51)
ICSSM_MII0/MII1_TXD3_ON: length 57
  TOP w0.147: R500.2 v1(100.52,106)
  L08_SIG2 w0.091: v1(100.52,106) 102.96,103.56 102.96,88.32 101.7,87.05 101.7,86.52 102.43,85.79 102.43,84.6 96.26,78.43 93.9,78.43 93.53,78.8 90.19,78.8 89.6,78.21 89.6,75.88 89.05,75.32 89.05,74.4 87.46,72.81 87.46,66.42 v1(85.67,64.63)
  BOTTOM w0.147: R500.2 v1(100.52,106) ; v1(85.67,64.63) U35.25
ICSSM_MII0/MII1_TXEN_ADD: length 18.2
  TOP w0.147: v1(75.98,94.79) 75.83,94.64 J8.35 ; R511.2 69.44,84.52 v1(69.77,84.86)
  BOTTOM w0.147: v1(75.98,94.79) 75.75,94.57 71.94,94.57 71,93.63 71,89.7 71.52,89.18 71.52,88.03 70.91,87.42 70.29,87.42 69.77,86.9 v1(69.77,84.86) 69.44,84.52 R511.2
ICSSM_MII0/MII1_TXEN_ON: length 57.3
  TOP w0.147: R495.2 v1(99.76,99.9)
  L08_SIG2 w0.091: v1(84.58,73.52) 84.08,73.03 84.08,70.76 84,70.67 83.71,70.67 83.54,70.84 83.54,74.1 84.3,74.87 85.79,74.87 87.03,76.11 87.03,77.59 90.27,80.83 94.19,80.83 95.11,81.75 96.02,81.75 97.96,83.69 97.96,88.02 98.64,88.7 98.64,89.35 98.95,89.66 98.95,94.81 98.07,95.69 98.07,95.89 98.17,96 98.89,96 98.99,96.1 98.99,96.26 98.89,96.36 98.17,96.36 98.07,96.47 98.07,96.62 98.17,96.73 98.89,96.73 98.99,96.84 98.99,96.99 98.89,97.09 98.17,97.09 98.07,97.2 98.07,97.35 98.17,97.46 98.89,97.46 98.99,97.57 98.99,97.72 98.89,97.83 98.17,97.83 98.07,97.93 98.07,98.08 98.17,98.19 98.89,98.19 98.99,98.3 98.99,98.45 98.89,98.56 98.17,98.56 98.07,98.66 98.07,98.82 98.17,98.92 98.88,98.92 98.98,99.03 98.98,99.18 98.87,99.29 98.17,99.29 98.07,99.4 98.07,99.84 98.52,100.3 99.36,100.3 v1(99.76,99.9)
  BOTTOM w0.147: v1(84.58,73.52) 85.26,73.52 86.42,72.36 U35.37 ; R495.2 v1(99.76,99.9)
ICSSM_MII0_COL: length 15.2
  TOP w0.147: v1(65.26,62.89) 65.73,62.42 66.73,62.42 67.44,63.13 70,63.13 70.76,63.89 70.76,65.07 71.09,65.4 72.38,65.4 72.93,64.85 72.93,63.86 73.9,62.89 U87.25
  BOTTOM w0.147: U82.13 65.76,62.39 v1(65.26,62.89)
ICSSM_MII0_COL_ADD: length 27.1
  BOTTOM w0.147: U82.24 72.35,63.39 72.81,63.85 72.81,64.52 70.57,66.76 68.68,66.76 67.48,67.96 67.48,76.37 68.5,77.39 68.5,77.83 70.3,79.64 70.3,81.35 70.96,82.01 70.96,83 71.41,83.45 R517.1
ICSSM_MII0_COL_ON: length 52.3
  TOP w0.147: R493.1 v1(97.55,96.93)
  L08_SIG2 w0.091: v1(97.55,96.93) 97.55,96.55 97.17,96.17 97.17,90.07 96.6,89.5 96.6,88.6 95.79,87.79 95.79,84.43 94.62,83.26 94.62,82.86 93.59,81.84 89.89,81.84 85.66,77.61 85.07,77.61 82.25,74.79 82.25,72.16 80.51,70.42 80.51,66.61 79.01,65.11 74.38,65.11 v1(72.17,62.89)
  BOTTOM w0.147: v1(72.17,62.89) U82.25
ICSSM_MII0_CRS: length 14.4
  TOP w0.147: U87.23 74.09,63.89 73.65,64.33 73.65,66.33 73.16,66.82 71.49,66.82 70.41,65.74 70.41,64.11 69.76,63.46 67.26,63.46 66.69,62.89 v1(66.18,62.89)
  BOTTOM w0.147: U82.14 v1(66.18,62.89)
ICSSM_MII0_CRS_ADD: length 23.6
  BOTTOM w0.147: R518.1 70.42,83.45 69.97,83 69.97,79.77 68.16,77.97 68.16,77.47 67.18,76.49 67.18,67.84 68.7,66.31 70.07,66.31 71.21,65.18 71.21,64.5 71.1,64.39 U82.22
ICSSM_MII0_CRS_ON: length 52.6
  TOP w0.147: R494.1 v1(97.55,97.92)
  L08_SIG2 w0.091: v1(72.17,63.89) 73.66,65.38 78.89,65.38 80.24,66.73 80.24,70.48 81.99,72.24 81.99,74.81 84.99,77.8 85.58,77.8 89.81,82.03 93.41,82.03 94.36,82.98 94.36,83.4 95.5,84.54 95.5,87.88 96.28,88.66 96.28,89.52 96.95,90.18 96.95,96.45 97.08,96.58 97.08,97.45 v1(97.55,97.92)
  BOTTOM w0.147: v1(72.17,63.89) U82.23
ICSSM_MII0_RXCLK: length 16.7
  TOP w0.147: v1(65.26,61.89) 65.08,61.71 65.08,61.38 65.29,61.17 66.51,61.17 66.69,60.99 66.69,60.2 66.83,60.06 67.15,60.06 67.33,60.24 67.33,60.81 67.6,61.08 70.01,61.08 70.14,61.21 70.14,61.83 70.27,61.96 70.45,61.96 70.58,61.83 70.58,61.21 70.71,61.08 70.92,61.08 71.06,60.94 71.51,60.94 71.92,61.35 72.47,61.35 72.62,61.2 72.62,60.55 72.8,60.37 73.04,60.37 73.57,60.89 U87.29
  BOTTOM w0.147: U82.11 65.76,61.39 v1(65.26,61.89)
ICSSM_MII0_RXCLK_ADD: length 27.4
  L08_SIG2 w0.091: v1(78.54,67.69) 78.33,67.69 77.76,68.26 76.88,68.26 76.33,67.71 76.33,66.25 76.05,65.97 75.11,65.97 74.77,66.31 74.77,67.2 74.63,67.33 73.87,67.33 73.73,67.46 73.73,67.65 73.87,67.79 74.63,67.79 74.77,67.92 74.77,68.14 74.2,68.7 72.13,68.7 70.74,70.09 70.32,70.09 70.01,69.78 70.01,66.15 71.71,64.45 71.71,61.85 v1(71.25,61.39)
  BOTTOM w0.147: R539.1 76.88,67.68 77.33,67.22 78.16,67.22 v1(78.54,67.69) ; U82.28 v1(71.25,61.39)
ICSSM_MII0_RXCLK_ON: length 57.8
  TOP w0.147: R483.1 v1(97.63,92.95)
  L08_SIG2 w0.091: v1(97.63,92.95) 98.11,92.47 98.11,90.3 97.17,89.37 97.17,83.98 95.57,82.39 94.81,82.39 93.88,81.45 90.07,81.45 86.35,77.73 86.35,77.06 85.73,76.44 84.5,76.44 82.76,74.7 82.76,71.92 80.99,70.15 80.99,63.82 80.53,63.36 78.75,63.36 78.49,63.11 78.49,62.88 78.39,62.77 78.04,62.77 77.93,62.66 77.93,62.51 78.04,62.4 78.39,62.4 78.49,62.3 78.49,62.14 78.39,62.04 78.04,62.04 77.93,61.93 77.93,61.78 78.04,61.67 78.39,61.67 78.49,61.56 78.49,61.28 78.11,60.89 74.83,60.89 74.72,60.79 74.72,60.45 74.61,60.34 74.46,60.34 74.35,60.45 74.35,60.79 74.25,60.89 74.09,60.89 73.99,60.79 73.99,60.45 73.88,60.34 73.73,60.34 73.62,60.45 73.62,60.79 73.51,60.89 73.36,60.89 73.26,60.79 73.26,60.45 73.15,60.34 73,60.34 72.89,60.45 72.89,60.79 72.78,60.89 v1(72.17,60.89)
  BOTTOM w0.147: v1(72.17,60.89) U82.29
ICSSM_MII0_RXD0: length 16.9
  TOP w0.147: v1(65.26,56.42) 65.26,55.06 66.01,54.31 68.92,54.31 69.26,54.65 70.93,54.65 71.85,55.57 73.35,55.57 74.26,54.65 76.15,54.65 76.72,55.22 U87.41
  BOTTOM w0.147: v1(65.26,56.42) 65.74,56.89 U82.2
ICSSM_MII0_RXD0_ADD: length 27.5
  TOP w0.147: R533.1 76.92,73.86 76.68,74.11 75.82,74.11 v1(75.34,73.63)
  L03_SIG1 w0.091: v1(75.34,73.63) 75.34,73.3 69.92,67.88 69.92,67.69 70.03,67.57 70.03,67.38 69.9,67.25 69.71,67.25 69.59,67.36 69.4,67.36 69.27,67.23 69.27,67.04 69.38,66.93 69.38,66.74 69.25,66.6 69.06,66.6 68.95,66.72 68.76,66.72 68.62,66.58 68.62,66.39 68.74,66.28 68.74,66.09 68.6,65.96 68.41,65.96 68.3,66.07 68.11,66.07 67.98,65.94 67.98,65.75 68.09,65.63 68.09,65.44 67.96,65.31 67.77,65.31 67.65,65.42 67.46,65.42 67.17,65.13 67.17,55.43 v1(67.5,55.11)
  BOTTOM w0.147: v1(67.5,55.11) 67.82,55.11 67.96,55.25 U82.42
ICSSM_MII0_RXD0_ON: length 57.5
  TOP w0.147: R476.1 83.79,82.11 84.35,82.67 84.97,82.67 v1(85.54,82.11)
  L03_SIG1 w0.091: v1(85.54,82.11) 85.19,82.11 84.34,82.96 79.95,82.96 79.21,82.21 79.21,75.77 78.6,75.16 75.2,75.16 74.61,74.57 74.61,73.34 66.63,65.36 66.63,62.64 66.35,62.36 65.01,62.36 64.7,62.06 64.7,61.23 65.06,60.87 65.06,59.02 64.43,58.39 64.11,58.39 63.93,58.57 63.93,60.82 63.75,61 63.51,61 63.31,60.8 63.31,56.79 65.88,54.22 68.07,54.22 68.46,54.62 v1(68.46,55.11)
  BOTTOM w0.147: U82.41 v1(68.46,55.11)
