# Allegro board PROC159B.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
(no net) on L03_SIG1: 38.82,2.28 38.77,2.33 17.42,2.33 17.42,7.1 15.27,7.1 15.27,13.03 15,13.3 10.02,13.3 10.02,18.91 12.7,18.91 13.58,19.8 13.58,22.09 13.84,22.34 14.73,22.34 15.36,21.7 15.9,21.7 16.4,22.21 19.3,22.21 19.3,23.1 16.38,23.1 15.87,23.61 15.24,23.61 14.85,23.23 13.84,23.23 13.71,23.36 13.71,24.88 12.31,26.28 10.02,26.28 10.02,76.95 10.27,76.7 34.79,76.7 37.97,73.52 45.08,73.52 45.46,73.9 45.46,96.63 44.83,97.27 41.65,97.27 41.27,97.65 41.27,108.19 70.87,108.19 74.81,104.25 78,104.25 81.6,107.85 107.59,107.85 113.74,101.7 113.74,78.73 101.6,78.73 101.6,59.3 113.74,59.3 113.74,26.15 105.66,26.15 105.66,23.47 106.54,22.59 109.98,22.59 109.98,16.37 105.78,16.37 105.41,16 105.41,11.16 113.74,11.16 113.74,7.1 112.15,7.1 112.15,2.65 88.9,2.65 88.9,13.3 70.35,13.3 70.35,8.88 70.64,7.84 71.43,7.1 67.88,7.1 67.88,2.54 43.25,2.54 43.25,5.2 41.04,7.42 38.82,5.2 ; 243 cut-outs
(no net) on L08_SIG2: 14.93,13.3 10.02,13.3 10.02,76.95 10.27,76.7 34.79,76.7 37.97,73.52 45.08,73.52 45.46,73.9 45.46,96.63 44.83,97.27 41.65,97.27 41.27,97.65 41.27,108.19 113.74,108.19 113.74,7.1 112.15,7.1 112.15,2.65 88.9,2.65 88.9,13.3 70.35,13.3 70.35,8.88 70.64,7.84 71.43,7.1 67.88,7.1 67.88,2.53 67.87,2.55 43.25,2.55 43.25,5.2 41.04,7.42 38.82,5.2 38.82,2.35 17.42,2.35 17.42,7.1 13.83,7.1 14.63,7.85 14.93,8.9 ; 241 cut-outs
ADC_DAC-VREF on TOP: 35.52,27.01 35.52,24.28 37.73,24.28 37.73,27.01
ADC_DAC-VREF on BOTTOM: 28.25,25.29 28.25,23.37 36.12,23.37 36.12,25.29
ADC_VREF1 on BOTTOM: 28.2,23.2 28.2,21.67 31.61,21.67 31.61,23.2
ADC_VREF2 on BOTTOM: 27.49,26.34 27.49,25.37 30.54,25.37 30.54,26.34
ADC_VREF3 on BOTTOM: 33.14,23.15 33.14,21.81 36.15,21.81 36.15,23.15
AM263_DAC_VREF on BOTTOM: 33.06,26.36 33.06,25.42 36.2,25.42 36.2,26.36
AM263_DAC_VREF0 on TOP: 27.94,27.59 27.94,24.99 32.86,24.99 32.86,27.59
BOOST_SW on TOP: 89.72,26.71 90.85,26.71 90.85,25.36 91.12,25.09 91.12,21.71 90.7,21.29 89.22,21.29 89.22,23.88 89.43,24.09 89.43,25.1 89.72,25.39
ETH_EARTH on TOP: 102.23,78.09 102.23,59.93 113.75,59.93 113.75,78.09
ETH_EARTH on BOTTOM: 102.23,78.09 102.23,59.93 113.74,59.93 113.74,78.09 ; 1 cut-out
ETH_EARTH on L02_GND1, L03_SIG1, L04_GND2, L05_PWR1, L06_PWR2, L07_GND3, L08_SIG2, L09_GND4: 102.23,78.09 102.23,59.93 113.15,59.93 113.15,78.09
HSEC_5V0 on TOP: 92.53,18.15 93.17,17.51 95.12,17.51 95.12,17.89 94.1,17.89 93.97,18.02 93.97,18.86 93.7,19.13 93.51,19.13 93.26,18.88 91.03,18.88 90.91,19 90.91,19.4 90.77,19.55 90.47,19.55 90.32,19.4 90.32,18.31 90.49,18.15
HSEC_5V0 on BOTTOM: 90.4,19.9 90.4,18.26 90.47,18.19 93.82,18.19 93.82,19.51 93.75,19.58 93.42,19.58 93.1,19.9 93.1,20.05 90.55,20.05
HSEC_5V0 on L05_PWR1: 30.73,2.65 30.73,10.27 32.25,11.8 55.49,11.8 60.45,16.75 77.03,16.75 77.71,16.08 88.85,16.08 89.77,15.15 91.46,15.15 92.76,16.45 92.76,17.98 92.58,18.17 90.36,18.17 90.36,19.99 95.54,25.17 101.3,25.17 104.82,21.66 104.82,10.99 105.28,10.53 112.39,10.53 112.39,5.58 89.32,5.58 88.92,5.97 88.92,13.31 88.91,13.32 70.35,13.32 70.23,13.2 70.23,7.1 67.88,7.1 67.88,2.65 43.25,2.65 43.25,5.2 41.04,7.42 38.82,5.2 38.82,2.65
OPSI_DQS on BOTTOM: 31.34,44.47 31.34,42.01 32.82,42.01 32.82,44.47
USBC_EARTH on TOP, L03_SIG1, L04_GND2, L05_PWR1: 106.04,11.8 106.04,15.74 110.61,15.74 110.61,23.23 106.8,23.23 106.29,23.74 106.29,25.51 113.79,25.51 113.79,11.8
USBC_EARTH on BOTTOM: 106.04,11.8 106.04,15.74 110.61,15.74 110.61,23.23 106.8,23.23 106.29,23.74 106.29,25.51 113.79,25.51 113.79,11.8
USBC_EARTH on L02_GND1, L06_PWR2, L07_GND3: 106.04,11.8 106.04,15.74 110.61,15.74 110.61,23.23 106.8,23.23 106.29,23.74 106.29,25.51 113.78,25.51 113.78,11.8
USBC_EARTH on L08_SIG2, L09_GND4: 106.04,11.8 106.04,15.74 110.61,15.74 110.61,23.23 106.8,23.23 106.29,23.74 106.29,25.51 113.79,25.51 113.79,11.8
VMAIN on TOP: 87.24,24.94 87.24,26.37 87.29,26.43 87.96,26.43 88.29,26.76 89.37,26.76 89.37,26.46 88.72,26.46 88.25,25.99 88.25,24.05 88.51,23.78 88.51,21.29 87.16,19.94 87.16,18.38 87.65,17.89 92.07,17.89 92.83,17.13 99.49,17.13 99.49,16.24 97.02,16.24 96.52,16.75 93.85,16.75 93.59,16.49 93.59,15.79 93.17,15.38 92.19,15.38 91.97,15.16 84.07,15.16 83.14,16.09 83.14,20.85
VMAIN on TOP: 53.34,78.11 53.34,77.23 53.88,77.23 54.1,77.02 54.1,72.06 57.88,68.28 57.88,65.96 58.31,65.53 58.31,63.67 58.47,63.51 58.99,63.51 59.15,63.68 59.15,66.24 59.69,66.78 59.69,67.99 59.19,68.49 59.19,69.8 56.03,72.96 56.03,77.56 55.48,78.11
VMAIN on BOTTOM: 97.42,90.48 97.42,86.94 100.09,86.94 100.09,90.48
VMAIN on BOTTOM: 83.48,16.76 83.48,21.43 84.74,22.69 86.44,22.69 86.44,19 87.42,18.02 90.1,18.02 90.34,17.78 93.48,17.78 93.48,15.91 91.6,15.91 91.19,15.5 84.74,15.5
VMAIN on BOTTOM: 53.84,80.38 53.84,79.32 53.33,78.81 53.29,78.85 52.77,78.85 52.7,78.79 52.7,77.49 53.05,77.14 55,77.14 55.24,77.38 55.24,77.71 55.11,77.84 55.11,78.47 54.1,79.49 54.1,80.38
VMAIN on L05_PWR1: 91.25,15.43 92.25,16.43 92.25,17.63 92.11,17.77 90.41,17.77 89.85,18.33 89.85,20.34 95.22,25.71 103.57,25.71 113.71,35.85 113.71,57.12 111.41,59.42 102.99,59.42 101.47,60.95 101.47,93.59 92.83,102.22 78.1,102.22 75.31,99.43 67.05,99.43 53.46,85.84 53.46,76.95 55.24,76.95 55.37,77.08 55.37,78.22 56.95,79.81 56.95,85.27 67.75,96.06 76,96.06 79.12,99.17 90.04,99.17 96.39,92.82 96.39,61.84 103.37,54.85 107.26,54.85 110.73,51.38 110.73,44.46 109.8,43.53 109.8,38.16 107.31,35.67 106.17,35.67 99.31,28.82 88.18,28.82 77.86,18.49 77.86,16.64 78.05,16.45 88.93,16.45 89.95,15.43
VMAIN on L06_PWR2: 92.45,17.4 92.45,25.71 89.34,28.82 54.22,28.82 53.72,28.31 53.72,27.04 54.55,26.2 78.46,26.2 79.65,26.15 89.33,16.48 89.33,16.17 90.01,15.49 91.2,15.49 91.6,15.89 91.6,16.56
VMAIN_12V0 on TOP: 90.57,35.26 94.89,35.26 96.06,34.1 99,34.1 100.58,35.67 100.58,38.09 101.85,38.09 101.85,35.42 101.53,35.1 101.53,30.65 99.77,28.89 96.95,28.89 96.13,29.71 96.13,30.65 95.45,31.33 94.23,31.33 93.29,32.27 91.82,32.27 91.46,31.91 91.46,30.82 91.32,30.68 90.78,30.68 90.39,30.29 90.39,28.54 90.18,28.33 90.18,27 90.17,26.99 89.58,26.99 89.58,28.05 88.48,29.15 87.56,29.15 86.83,29.89 86.83,31.53 87.6,32.3 87.6,32.3
VMAIN_12V0 on BOTTOM: 99.5,28.09 99.5,29.2 100.96,30.66 100.96,34.86 100.68,35.14 100.03,35.14 98.48,33.59 91.99,33.59 91.94,33.54 91.94,32.38 96.23,28.09
VMAIN_12V0 on L06_PWR2: 16.76,23.86 16.76,22.85 19.81,19.8 19.81,11.93 21.84,9.89 69.84,9.89 70.22,10.28 70.22,13.19 70.36,13.34 88.91,13.34 88.91,9.39 89.33,8.98 92.91,8.98 93.47,9.54 93.47,14.33 96.64,17.51 96.64,24.32 100.71,28.38 100.71,33.77 100.01,34.46 97.93,34.46 93.04,29.58 93.04,17.27 92.04,16.27 92.04,15.77 91.4,15.13 89.78,15.13 79.27,25.64 68.96,25.64 66.8,23.48 66.8,14.47 64.13,11.8 22.73,11.8 21.2,13.32 21.2,14.85 22.35,15.99 22.35,20.31 21.59,21.07 21.2,21.07 21.2,22.21 19.55,23.86
VPP_1V7 on TOP: 84.96,46.6 84.96,45.04 85.55,44.45 86.38,44.45 86.38,45.83 87.49,45.83 87.63,45.96 88.51,45.96 88.51,46.6
VPP_R on L05_PWR1: 50.54,37.07 50.54,35.67 54.86,35.67 54.86,37.07
VSYS_1V2 on TOP: 82.99,52.46 82.99,51.12 86.33,51.12 86.33,52.13 86.54,52.33 87.9,52.33 88.16,52.59 88.16,54.24 89.14,55.23 90.03,55.23 90.8,55.99 90.8,57.14 89.78,57.14 89.27,56.62 84.85,56.62 84.85,54.33
VSYS_1V2 on BOTTOM: 82.17,51.83 82.17,50.33 84.79,50.33 84.8,50.34 84.8,50.65 86.28,52.13 86.28,54.44 84.78,54.44
VSYS_1V2_SW on TOP: 84.85,58.95 84.85,57.01 91.05,57.01 91.05,57.52 90.03,57.52 88.59,58.95
VSYS_3V3_LDO1 on TOP: 102.45,54.45 102.45,44.31 103.34,44.31 103.34,49.74 103.75,50.15 103.75,56.88 101.62,56.88 101.24,56.5 101.24,55.66
VSYS_3V3_LDO1 on BOTTOM: 62.61,12.69 62.61,9.89 66.23,9.89 67.45,11.12 67.45,12.69
VSYS_3V3_LDO1 on BOTTOM: 102.23,57.58 102.23,47.6 104.01,47.6 104.01,57.58
VSYS_3V3_LDO1 on L05_PWR1: 10.02,13.3 10.02,108.19 113.74,108.19 113.74,43.76 109.41,39.42 108.9,39.42 98.86,29.39 88,29.39 76.06,17.45 60.18,17.45 56.03,13.3 ; 6 cut-outs
VSYS_3V3_LDO1 on L06_PWR2: 73.02,93.21 73.02,108.19 101.72,108.19 101.72,93.21
VSYS_3V3_LDO2 on TOP: 102.48,37.2 102.48,34.79 103.5,34.79 103.63,34.66 103.63,34.28 104.14,34.28 104.14,35.67 104.01,35.8 103.12,35.8 103.12,37.2
VSYS_3V3_LDO2 on TOP: 11.04,58.79 11.04,56.76 14.73,56.76 14.73,58.79
VSYS_3V3_LDO2 on BOTTOM: 101.47,38.21 101.47,34.25 105.02,34.25 105.02,38.21
VSYS_3V3_LDO2 on L03_SIG1: 103.59,36.95 103.59,34.17 105.62,34.17 105.62,36.95
VSYS_3V3_LDO2 on L06_PWR2: 11.68,59.17 11.68,49.64 24.25,37.07 24.25,27.04 37.71,27.04 37.71,36.82 53.21,52.31 87.88,52.31 88.51,52.95 88.51,61.33 74.42,61.33 72.77,62.98 72.77,76.46 71.59,77.63 69.51,77.63 69.21,77.34 69.21,73.83 64.43,69.05 54.6,69.05 52.84,67.3 22.35,67.3 15.24,60.19 12.7,60.19
VSYS_TA_3V3 on BOTTOM: 54.35,82.66 54.35,81.9 56.13,81.9 57.79,83.56 61.34,83.56 61.34,87.57 55.65,87.57 55.25,87.17 55.25,83.56
VSYS_TA_3V3 on BOTTOM: 44.83,102.98 44.83,101.46 45.21,101.07 45.21,97.66 45.22,97.65 46.35,97.65 46.35,102.98
VSYS_TA_3V3 on L06_PWR2: 43.3,108.06 43.3,99.05 46.22,96.13 46.22,74.79 44.32,72.89 16.4,72.89 16.25,72.73 16.25,71.41 16.43,71.23 48.89,71.23 54.73,77.08 63.47,77.08 67.75,81.36 67.75,108.06
VSYS_TA_3V3_SW on BOTTOM: 53.84,82.03 54.1,82.03 54.1,83.28 54.78,83.96 54.78,87.42 54.58,87.62 52.95,87.62 52.7,87.36 52.7,83.81 53.84,82.66
XDS_GND on TOP: 10.02,77.71 10.02,108.19 40.64,108.19 40.64,97.02 41.27,96.38 44.57,96.38 44.57,74.92 43.94,74.28 38.86,74.28 38.86,74.41 35.56,77.71 ; 2 cut-outs
XDS_GND on TOP: 10.02,84.7 10.02,88 14.47,88 14.47,84.7
XDS_GND on BOTTOM: 10.02,77.84 10.02,106.43 11.78,108.19 40.64,108.19 40.64,96.63 44.32,96.63 44.57,96.38 44.57,74.94 44.6,74.94 44.06,74.41 38.92,74.41 35.49,77.84 ; 2 cut-outs
XDS_GND on BOTTOM: 10.41,87.87 10.41,85.2 14.09,85.2 14.09,87.87
XDS_GND on BOTTOM: 21.84,80.51 21.84,78.22 27.68,78.22 27.68,80.51
XDS_GND on L02_GND1, L03_SIG1, L04_GND2, L07_GND3, L09_GND4: 10.02,77.85 10.02,108.19 40.64,108.19 40.64,97.02 41.02,96.63 44.32,96.63 44.57,96.38 44.57,74.41 38.86,74.41 35.49,77.77 10.09,77.77 ; 1 cut-out
XDS_GND on L06_PWR2: 10.02,77.85 10.02,108.19 40.64,108.19 40.64,97.02 41.02,96.63 44.32,96.63 44.57,96.38 44.57,74.41 38.86,74.41 35.49,77.77 10.09,77.77 ; 2 cut-outs
XDS_GND on L08_SIG2: 10.02,77.85 10.02,108.19 40.64,108.19 40.64,97.02 41.02,96.63 44.32,96.63 44.57,96.38 44.57,74.41 38.86,74.41 35.49,77.77 10.09,77.77 ; 6 cut-outs
XDS_SHIELD on TOP, L02_GND1, L03_SIG1, L04_GND2, L05_PWR1, L06_PWR2, L07_GND3, L08_SIG2, L09_GND4: 9.27,99.43 9.27,88.63 13.58,88.63 13.58,92.82 11.68,92.82 11.68,97.27 13.71,97.27 13.71,99.43
XDS_SHIELD on BOTTOM: 9.27,99.43 9.27,88.63 13.58,88.63 13.58,92.82 11.68,92.82 11.68,97.27 13.71,97.27 13.71,99.43 ; 1 cut-out
N32995608 on BOTTOM: 96.75,87.07 96.75,80.34 99.32,80.34 99.32,86.56 101.66,86.56 101.66,87.07
N34755833 on TOP: 98.55,36.32 98.55,38.09 99.31,38.09 99.31,36.45 99.56,36.19 99.56,35.94 99.31,35.69 98.67,35.69 98.42,35.94 98.42,36.19
N34755833 on BOTTOM: 91.56,40.75 91.56,39.1 94.61,39.1 96.89,36.82 97.66,36.82 98.68,35.8 99.82,35.8 99.82,37.71 98.93,38.6 98.93,40.75
N34755845 on TOP: 98.55,45.96 98.55,44.31 99.31,44.31 99.31,45.83 99.56,46.09 99.56,46.34 99.31,46.6 98.67,46.6 98.42,46.34 98.42,46.09
N34755845 on BOTTOM: 94.74,45.83 94.74,41.27 98.84,41.27 98.84,43.21 100.07,44.44 100.07,46.72 98.29,46.72 98.29,45.96 98.17,45.83
N34780660 on BOTTOM: 99.54,65.82 99.54,61.5 101.57,61.5 101.57,65.82

Small or netless copper shapes (teardrops, artwork): 829 on TOP, 843 on BOTTOM, 450 on L03_SIG1, 2 on L05_PWR1, 1 on L06_PWR2, 463 on L08_SIG2

## Text on the board
Ref Des/Assembly Bottom: PROC159B ASSEMBLY BOTTOM
Ref Des/Silkscreen Bottom: B | C | A | FOR EVALUATION ONLY; | NOT FCC APPROVED FOR RESALE | ASSY
User.Comments: CR_1_2 | CR_1_1 | BOARD NAME: | AM263P CC | REV: B | DATE: 25/03/25 | DESCRIPTION: | SHEET | OF | 17 | PROC159B | SCALE: 1 | TEXAS INSTRUMENTS
Ref Des/Assembly Top: PROC159B ASSEMBLY TOP
Ref Des/Silkscreen Top: 3 | 2 | ETHERNET | CONN_0 | OPN# | SL# | PCB#: PROC159B
PAGE_OUTLINE: LAYOUT BY | REVIEWED BY | APPROVED BY | SIGNATURES | AMB | ZA | NP | DATE | 250325 | SCALE: | SIZE | D | NONE | TEXAS INSTRUMENTS | SHEET 1 OF 17 | PROC159B | Rev | B
DISPLAY_TOP: 19. | 18. | 16. | 17. | ALL BOARD OUTLINE INNER ANGLES THAT ARE NOT EXPLICITY DIMENTIONED SHALL BE WITH TOOL PATH 1.0MM DIA OR SMALLER. | EDGE FINGERS SHALL HAVE HARD GOLD FINISH AS PER IPC6012. | ENSURE UL REGISTERED E-FILE NUMBER SHALL BE PRINTED ON THE PCB SILKSCREEN. | VIA ON PAD SHALL BE RESIN FILLED AND CAP-PLATED.
User.16: TITLE: | MISTRAL | AM62A AUTOMOTIVE RGMII | R | #60, ADARSH REGENT, 100'FT RING ROAD, | MISTRAL SOLUTIONS PVT.LTD., | DOMLUR EXTENSION, BANGALORE-560 071 | TOP ASSEMBLY OF PROC151E1 | 8 | A | 5 | 4 | 28 | SK-ETH-AUTO-DCO2 | PROC151E1 | 9 | 19 | 3 | 2 | SHEET    OF 13 | 50 | 49 | BOTTOM ASSEMBLY OF PROC151E1 | DATE: | 20AUG22 | REV | E1 | SCALE: 1
User.17: 8 | 5 | 4 | 28 | 9 | 19 | 3 | 2 | 50 | 49 | A | SK-ETH-AUTO-DCO2 | PROC151E1 | R | TOP ASSEMBLY OF PROC151E1 | BOTTOM ASSEMBLY OF PROC151E1 | TITLE: | AM62A AUTOMOTIVE RGMII | #60, ADARSH REGENT, 100'FT RING ROAD, | MISTRAL SOLUTIONS PVT.LTD., | DOMLUR EXTENSION, BANGALORE-560 071 | SHEET    OF 13 | DATE: | 20AUG22 | REV | E1 | SCALE: 1 | MISTRAL
User.45: 03 | 04 | 05 | 06 | STRIPLINE | MICROSTRIP | EDGE COUPLED STRIPLINE | EDGE COUPLED MICROSTRIP | L3,L8 | L1,L10 | L8 | 3.6 | 5.8 | 4.2 | 3.7 | NA | 4.4 | 6 | FIGURE | 50 | 90 | SIZE | 8.0 | 36.0 | 40.0 | 44.0 | 66.0 | 32.0 | 108.0 | 126.0 | 62.0x24.0 | 76.0x28.0 | 82.0x24.0 | L2/L4,L7/L9 | L2,L9 | L7/L9 | DRILL CHART: TOP to BOTTOM | ALL UNITS ARE IN MILS | TOLERANCE | +3.0/-3.0 | +2.0/-2.0 | PLATED | NON-PLATED | QTY | 2223 | 14 | 18 | 12 | 22 | 2 | 21 | 11 | 6 - Provide serial numbers to the assembled boards for identification. | 7 - The assembled board are wrapped in ESD Covers(individual) and packed securely before shipment. | ASSEMBLY NOTES:- | 1 - All MSL components should be baked as per JEDEC standard. | 2 - PCB should be baked at 120 degree for 8 hours. | 3 - Board assembly must comply with workmanship standards IPC-A-610 Class 2, unless otherwise specified. | 4 - These assemblies are ESD sensitive, ESD precautions shall be observed. | 5 - These assemblies must be clean and free from flux and all contaminants. Use of no clean flux is not acceptable. | PROC101 E2 ASSEMBLY TOP | PROC101 E2 ASSEMBLY BOTTOM
