# Allegro board PROC159B.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N34665847: length 3.5
  BOTTOM w0.147: R304.2 65.15,100.42 65,100.57 63.97,100.57 63.74,100.8 J11.38
N34665853: length 4
  BOTTOM w0.147: R305.2 66.16,100.7 65.91,100.95 64.39,100.95 64.24,101.1 J11.39
N34666564: length 5.4
  TOP w0.147: R312.1 R309.2 41.06,77.2 41.32,77.46 U46.6 v1(43.94,77.46)
  BOTTOM w0.147: R310.1 v1(43.94,77.46)
N34666567: length 5.3
  TOP w0.147: R308.2 R313.1 41.14,76.06 41.27,76.19 U46.7 v1(43.94,76.19)
  BOTTOM w0.147: R311.1 44.01,76.26 v1(43.94,76.19)
N34733472: length 2.8
  TOP w0.147: U7.23 108.69,36.55 109.67,35.58 109.67,35.54 TP13.1
N34733475: length 3.2
  TOP w0.147: TP15.1 109.67,46.65 109.02,46.65 108.69,46.32 108.69,46.23 108.69,46.23 108.69,45.92 108.69,45.92 U7.26
N34733595: length 5.6
  TOP w0.147: U7.31 106.19,46.57 v1(105.66,47.1)
  BOTTOM w0.147: R32.2 105.87,44.94 105.24,45.57 105.24,46.68 v1(105.66,47.1)
N34755833: length 2.7
  TOP w0.305: U7.3 98.69,36.09 v1(98.67,36.07) ; v1(99.31,36.07) 99.19,36.18 U7.4
N34755845: length 2.7
  TOP w0.305: v1(98.67,46.22) 98.69,46.2 U7.46 ; U7.45 99.19,46.1 v1(99.31,46.22)
N34755854: length 13.2
  TOP w0.147: U7.5 99.69,36.33 99.76,36.25 99.76,35.59 v1(99.33,35.16)
  L08_SIG2 w0.091: v1(90.77,38.03) 92.15,38.03 95.38,34.79 98.96,34.79 v1(99.33,35.16)
  BOTTOM w0.147: C55.2 v1(90.77,38.03)
N34755863: length 6.5
  TOP w0.147: v1(98.67,47.1) 99.18,47.1 99.76,46.52 99.76,46.03 99.69,45.96 U7.44
  BOTTOM w0.147: C56.2 96.01,47.01 96.44,47.44 98.34,47.44 v1(98.67,47.1)
N34755869: length 1.3
  BOTTOM w0.147: C55.1 92.85,38.78 R28.1
N34756880: length 8
  TOP w0.147: U7.19 v1(106.69,36.18)
  L03_SIG1 w0.091: v1(112.57,36.8) 111.95,36.18 v1(106.69,36.18)
  BOTTOM w0.147: v1(112.57,36.8) R36.1
N34775734: length 2.5
  TOP w0.147: C82.1 92.72,59.78 92.02,59.09 91.24,59.09 91.1,58.94 U9.8
N34778760: length 13.7
  L08_SIG2 w0.091: v1(92.58,72.93) 91.92,72.28 v1(91.92,64.14)
  BOTTOM w0.147: U35.13 v1(91.92,64.14) ; TP61.1 94.09,72.93 v1(92.58,72.93) 92.5,72.93 91.92,72.36 U35.48
N34779936: length 1.4
  TOP w0.147: R222.2 111.88,55.66 111.63,55.91 Q7.1
N34780102: length 8
  TOP w0.147: R207.1 R211.1 72.08,37.22 71.58,36.72 70.12,36.72 68.07,38.77 67.04,38.77 U1.L18
N34780104: length 8.9
  TOP w0.147: U1.L17 66.58,38.43 67.99,38.43 70,36.42 71.6,36.42 72.08,35.95 R209.1 R208.1
N34780660: length 2.3
  BOTTOM w0.381: FL3.2 100.44,63.32 100.38,63.39 J7.2
N34780919: length 1.4
  BOTTOM w0.147: Q8.1 112.93,58.5 R223.2
N34780978: length 2.9
  BOTTOM w0.147: U35.29 84.98,67.84 84.26,67.12 84.26,66.78 83.67,66.19 R210.2
N34780980: length 1.9
  BOTTOM w0.147: R213.1 91.31,73.24 90.92,72.85 U35.46
N34780998: length 2.3
  BOTTOM w0.147: R212.2 83.67,69.93 84.25,69.34 U35.32
N34781014: length 1.4
  BOTTOM w0.147: Q6.1 R221.2
N34781978: length 0.9
  TOP w0.147: U15.3 R81.2
N34798910: length 1.2
  BOTTOM w0.147: C99.1 89.41,80.71 U16.4
N34800889: length 3.8
  TOP w0.147: U1.M1 51.55,38.03 50.2,39.38 R94.2
N34800895: length 5.1
  TOP w0.147: R96.2 50.2,40.42 52.19,38.43 53.78,38.43 U1.L2
N34801624: length 8.6
  TOP w0.147: U1.K2 v1(53.78,39.23)
  BOTTOM w0.147: v1(53.78,39.23) 53.06,39.23 51.6,40.69 51.6,41.32 50.92,41.99 50.92,42.48 50.78,42.62 R191.1
N34801627: length 8.9
  TOP w0.147: U1.K4 v1(55.38,39.23)
  BOTTOM w0.147: R192.1 50.81,44.35 51.65,43.52 51.65,42.47 52.33,41.8 52.33,40.96 53.23,40.06 54.55,40.06 v1(55.38,39.23)
N34801685: length 5.2
  TOP w0.147: R194.1 50.76,43.99 51.97,42.78 51.97,41.84 U1.J1
N34801688: length 16.4
  TOP w0.147: U1.J4 v1(55.38,40.83) ; v1(55.72,53.09) 56.08,52.73 R195.1
  L03_SIG1 w0.091: v1(55.72,53.09) 56.07,52.73 56.07,50.61 57.19,49.5 57.19,48.56 57.38,48.37 57.38,41.43 57.17,41.23 55.78,41.23 v1(55.38,40.83)
N34801691: length 7.3
  TOP w0.147: U1.K3 v1(54.58,39.23)
  BOTTOM w0.147: v1(54.58,39.23) 54.13,39.69 53.1,39.69 51.89,40.9 51.89,41.54 51.3,42.13 51.3,42.79 50.89,43.21 R196.1
N34820051: length 3.9
  BOTTOM w0.147: R295.2 55.88,100.7 56.13,100.95 57.48,100.95 57.74,101.21 J11.26
N34820524: length 2.3
  TOP w0.147: Q5.2 92.96,41.2 93.09,41.33 R200.2
N34820530: length 2
  TOP w0.147: LD8.2 Q5.3
N34828765: length 1.3
  TOP w0.147: R72.2 LD5.2
N34828799: length 2.2
  TOP w0.147: R73.2 51.07,75.56 51.62,75.01 LD4.2
N34828801: length 1.5
  TOP w0.147: LD4.1 Q2.3
N34828819: length 1.5
  TOP w0.147: R76.1 55.22,79.09 54.96,78.83 Q2.1
N34830317: length 3.2
  BOTTOM w0.147: U12.10 97.72,57.62 C92.1 98.19,57.52 98.93,57.52 99.23,57.22 R69.1
N34830329: length 5.1
  BOTTOM w0.147: R71.1 99.27,58.24 98.93,57.9 98.43,57.9 C92.2 ; C92.2 97.81,58.12 U12.9 ; C92.2 97.7,58.62 U12.8
N34830425: length 3.5
  BOTTOM w0.147: U13.10 87.09,53.58 87.06,53.55 C91.1 87.37,52.65 87.37,52.18 R68.1
N34830437: length 5.6
  BOTTOM w0.147: R70.1 87.75,52.09 87.75,52.57 88.04,52.86 C91.2 ; U13.8 88.09,53.6 88.04,53.55 C91.2 ; U13.9 87.59,53.4 C91.2
N34853373: length 4.7
  TOP w0.147: R543.1 C379.2 51.53,93.46 v1(52.09,92.9)
  BOTTOM w0.147: U76.6 52.56,93.37 v1(52.09,92.9)
N34869480: length 3.3
  TOP w0.147: U78.6 82.19,35.05 82.51,35.37 R431.2 R432.2
N34869775: length 1.3
  BOTTOM w0.147: C57.1 R29.2
N35052540: length 1.2
  BOTTOM w0.147: R7.1 103.31,13.13 U17.5
N35052638: length 1.7
  TOP w0.147: R18.1 94.85,15.27 95.02,15.43 U4.10
N35052879: length 2.3
  TOP w0.147: U3.6 99.8,18.55 99.43,18.92 C9.1
N35052899: length 2.1
  BOTTOM w0.147: R6.2 103.63,11.6 103.31,11.93 102.97,11.93 102.55,12.35 U17.6
N35052954: length 1.8
  BOTTOM w0.147: R2.2 103.54,15.18 103,14.63 103,14.22 102.7,13.93 U17.3
N35052969: length 2.8
  BOTTOM w0.147: U17.9 101.05,12.39 100.71,12.05 99.9,12.05 TP1.1
N35053013: length 1.9
  BOTTOM w0.147: U17.11 100,13.53 R8.1
N35053423: length 1.7
  TOP w0.147: U4.11 95.52,15.31 95.8,15.03 C16.1
N35056553: length 1.7
  TOP w0.147: LD1.2 102.2,14.86 101.86,14.53 R1.2
N35059517: length 4.7
  TOP w0.147: U1.B10 v1(60.98,46.43)
  BOTTOM w0.147: R141.2 62.69,48.77 60.98,47.06 v1(60.98,46.43)
N35065419: length 12.4
  TOP w0.147: U7.12 103.19,36.31 v1(103.42,36.08)
  L08_SIG2 w0.091: v1(94.4,37.06) 94.77,37.06 95.22,36.61 100.67,36.61 101.82,35.46 102.79,35.46 v1(103.42,36.08)
  BOTTOM w0.147: R42.1 v1(94.4,37.06)
N35071225: length 10.1
  TOP w0.147: U7.18 106.19,36.36 106.19,36.36 106.19,35.73 106.29,35.63 106.29,35.62 v1(106.62,35.3)
  L03_SIG1 w0.091: v1(106.62,35.3) 107.21,34.7 107.21,29.91 v1(108.02,29.1)
  BOTTOM w0.147: R435.1 107.57,28.65 v1(108.02,29.1)
N35139843: length 12.4
  TOP w0.147: U7.34 v1(104.69,46.09)
  L03_SIG1 w0.091: v1(111.04,53.24) 108.34,50.54 108.34,48.55 106.39,46.6 105.21,46.6 v1(104.69,46.09)
  BOTTOM w0.147: v1(111.04,53.24) 110.92,53.12 R142.1
N35230144: length 2.2
  TOP w0.147: R439.1 29.93,56.79 30.35,56.38 U18.5
N35230147: length 1.6
  TOP w0.147: R440.1 40.11,53.84 U18.2
N35230153: length 1.6
  TOP w0.147: U18.7 R442.1
N35244293: length 3.7
  TOP w0.147: R452.1 36.1,43.66 35.64,44.11 33.3,44.11 U19.D2
N35244332: length 3.2
  TOP w0.147: R453.1 28.58,42.3 28.81,42.08 30.26,42.08 U19.C4
N35244360: length 3.3
  TOP w0.147: U19.D4 30.26,44.24 28.59,44.24 28.03,44.8 R454.1
N35244387: length 2
  TOP w0.147: U19.D5 29.39,43.66 29.25,43.8 28.71,43.8 28.48,43.57 R455.1
N35244414: length 3.2
  TOP w0.147: U19.E3 31.85,46.11 31.33,46.63 R456.1
N35244441: length 3.4
  TOP w0.147: U19.E2 33.85,45.66 R457.1
N35244468: length 2.6
  TOP w0.147: U19.E1 34.38,44.66 35.13,45.41 R458.1
N35248046: length 4.3
  TOP w0.147: R451.1 32.6,45.01 32.43,44.83 32.43,44.24 U19.D3
N35252647: length 1.6
  TOP w0.147: R441.1 40.11,55.11 U18.3
N35271296: length 2
  TOP w0.147: TP78.1 17.96,25.36 18.42,24.91 U29.8
N35329968: length 5.4
  TOP w0.147: U1.L3 v1(54.58,38.43)
  BOTTOM w0.147: v1(54.58,38.43) 52.77,38.43 51.52,39.69 R117.2
N35329989: length 5.3
  TOP w0.147: U1.M3 v1(54.58,37.63)
  BOTTOM w0.147: R118.2 52.07,38.54 52.52,38.1 54.11,38.1 v1(54.58,37.63)
N35342843: length 1.5
  TOP w0.147: U57.15 44.2,105.26 R371.1
N35343433: length 1.6
  TOP w0.147: R372.1 44.07,103.99 U57.14
N35343436: length 1.5
  TOP w0.147: R373.1 44.2,102.72 U57.13
N35343439: length 1.6
  TOP w0.147: U57.12 44.07,101.45 R374.1
N35343442: length 1.5
  TOP w0.147: U57.11 44.2,100.18 R375.1
N35343445: length 1.5
  TOP w0.147: U57.10 44.2,98.91 R376.1
N35345342: length 1.8
  BOTTOM w0.147: R378.1 18.51,73.05 18.51,73.06 U58.7
N35373997: length 4.6
  TOP w0.147: R315.1 41.28,79.36 41.91,78.73 U46.5 v1(43.94,78.73)
  BOTTOM w0.147: v1(43.94,78.73) 44.18,78.48 R314.1
N35375175: length 2.1
  BOTTOM w0.147: R34.1 J20.1
N35376496: length 3.2
  BOTTOM w0.147: J21.1 17.71,17.22 17.69,17.25 R175.2 R31.1
N35387120: length 3.5
  TOP w0.147: R116.1 23.28,26.83 22.9,26.45 22.9,25.22 22.59,24.91 U29.7
N35387809: length 4.6
  TOP w0.147: v1(44.79,41.82) 43.93,40.95 R1678.1
  BOTTOM w0.147: U80.8 43.79,40.82 v1(44.79,41.82)
N35395797: length 2.2
  TOP w0.147: U20.15 52.77,64.96 53.35,64.38 R461.1
N35654609: length 1.7
  TOP w0.147: Q20.2 R3832.2
N35654631: length 1.7
  TOP w0.147: LD19.2 Q20.3
N35656175: length 1.3
  TOP w0.147: LD2.2 R47.2
N35656498: length 1.3
  TOP w0.381: R3833.2 LD20.2
N35656998: length 1.1
  TOP w0.147: R3834.2 LD21.2
N35657235: length 1.3
  TOP w0.381: R3835.2 LD22.2
N35672996: length 3.3
  TOP w0.147: SW15.2 62.89,55.21 62.51,55.59 R3842.2
N35712813: length 55.9
  TOP w0.147: R116.2 24.79,27.42 27.1,29.73 36.83,29.73 37.97,28.59 37.97,27.04 39.16,25.84 40.23,25.84 41.07,25.01 47.58,25.01 50.86,21.73 65.76,21.73 67.05,20.43 73.58,20.43 J22.2
N35805242: length 14.2
  TOP w0.147: U1.F18 67.32,43.17 67.99,43.17 70.26,45.44 75.55,45.44 76.94,46.83 v1(76.94,48.25)
  BOTTOM w0.147: v1(76.94,48.25) 77.2,48.5 R247.1
N35805430: length 8.2
  TOP w0.147: U1.C18 67.69,45.23 69.37,46.91 71.11,46.91 v1(72.71,48.51)
  BOTTOM w0.147: v1(72.71,48.51) 73.07,48.51 73.21,48.66 R255.1
N35805533: length 16.9
  TOP w0.147: v1(75.59,46.26) 76.34,47.01 76.34,48.81 76.82,49.29 R248.1 ; U1.G16 v1(65.78,42.43)
  BOTTOM w0.114: v1(65.78,42.43) 65.78,42.43 66.18,42.03 67.63,42.03 67.8,42.2
  BOTTOM w0.147: 67.8,42.2 68.66,43.06 68.66,44.82 69.92,46.08 74.96,46.08 75.14,46.26 v1(75.59,46.26)
N35805539: length 12.7
  TOP w0.147: U1.E17 66.58,44.03 67.97,44.03 69.97,46.03 73.99,46.03 74.75,46.79 74.75,47.85 75.64,48.73 R249.1
N35805550: length 12.3
  TOP w0.147: v1(75.56,47.99) 75.56,47.12 74.17,45.73 70.14,45.73 68.04,43.63 U1.E18
  BOTTOM w0.147: v1(75.56,47.99) 75.56,48.44 75.73,48.61 R250.1
N35805561: length 13.7
  TOP w0.147: U1.F16 v1(65.78,43.23) ; v1(73.93,46.78) 73.93,47.82 74.42,48.31 R251.1
  BOTTOM w0.114: v1(65.78,43.23) 65.78,43.23 66.18,42.83 66.88,42.83 67.07,43.02
  BOTTOM w0.147: 67.07,43.02 67.95,43.9 67.95,44.71 69.73,46.49 73.05,46.49 73.34,46.78 v1(73.93,46.78)
N35805574: length 10.2
  TOP w0.147: U1.F15 v1(64.98,43.23)
  BOTTOM w0.114: 66.36,43.84 66.15,43.63 65.38,43.63 v1(64.98,43.23)
  BOTTOM w0.147: 66.36,43.84 69.36,46.84 70.49,46.84 70.85,47.2 R252.1
N35805586: length 9.5
  TOP w0.147: v1(70.27,47.37) 71.03,47.37 71.98,48.31 R253.1 ; U1.E16 v1(65.78,44.03)
  BOTTOM w0.147: v1(70.27,47.37) 69.12,47.37 v1(65.78,44.03)
N35805597: length 9.8
  TOP w0.147: U1.D18 67.82,44.43 69.71,46.32 71.74,46.32 v1(73.93,48.51)
  BOTTOM w0.147: R254.1 74.43,48.66 74.29,48.51 v1(73.93,48.51)
N35805610: length 9.6
  TOP w0.147: U1.D17 66.57,44.82 67.79,44.82 69.59,46.62 71.5,46.62 73.2,48.31 R256.1
N35805636: length 5.7
  TOP w0.147: U1.B18 67.46,46.03 69.57,48.14 69.57,48.27 69.81,48.51 v1(70.27,48.51)
  BOTTOM w0.147: R257.1 69.63,48.68 69.8,48.51 v1(70.27,48.51)
N35805639: length 5.1
  TOP w0.147: U1.B17 66.57,46.42 67.28,46.42 69.54,48.68 R258.1
N35805644: length 6.1
  TOP w0.147: U1.D16 v1(65.78,44.83)
  BOTTOM w0.147: R259.1 68.41,47.46 v1(65.78,44.83)
N35805649: length 6.9
  TOP w0.147: U1.C17 66.57,45.62 67.53,45.62 69.8,47.89 70.41,47.89 70.76,48.24 R260.1
N35805656: length 3.8
  TOP w0.147: R261.1 67.57,49.29 66.52,48.24 66.52,47.17 U1.A17
N35805662: length 4.8
  TOP w0.147: U1.C16 v1(65.78,45.63)
  BOTTOM w0.147: R262.1 67.19,47.96 66.35,47.12 66.35,46.2 v1(65.78,45.63)
N35805667: length 5.5
  TOP w0.147: R1652.1 66.43,49.08 v1(66.22,48.87) ; U1.C15 v1(64.98,45.63)
  BOTTOM w0.114: 65.38,47.56 65.38,46.03 v1(64.98,45.63)
  BOTTOM w0.147: v1(66.22,48.87) 65.38,48.03 65.38,47.56
N35805672: length 6.1
  TOP w0.147: R1653.1 v1(65.2,48.85) ; U1.D15 v1(64.98,44.83)
  BOTTOM w0.114: v1(64.98,44.83) 64.58,45.23 64.58,47.56
  BOTTOM w0.147: v1(65.2,48.85) 64.58,48.24 64.58,47.56
N35820709: length 1.6
  TOP w0.147: SW14.2 R3858.2
N35821153: length 4.8
  BOTTOM w0.147: U88.19 83.59,107.33 83.93,107.67 86.37,107.67 86.59,107.46 R1399.2
N35824901: length 1.9
  BOTTOM w0.147: U81.9 70.82,29.38 70.37,29.83 R475.2
N35842882: length 1.6
  BOTTOM w0.147: R3870.2 U90.9
N35844058: length 1.6
  TOP w0.147: SW16.2 R3872.2
N35920046: length 3.5
  TOP w0.203: U5.2 92.14,26.61 92.4,26.35 92.4,25.16 93.18,24.38 C23.1
N35924469: length 1.3
  TOP w0.203: C22.1 94.66,29.22 94.44,29 R552.2
N35925251: length 3.1
  TOP w0.203: R554.1 R553.2 U5.3
N35926311: length 1.7
  TOP w0.203: U5.10 88.96,26.11 88.76,25.91 C375.1

## Copper pours and planes (outline as drawn)
DGND on L03_SIG1 (solid shape): 37.1,16.25 37.21,16.27 37.27,16.18 37.27,11.13 37.09,10.95 36.98,10.93 36.92,11.02 36.92,16.07
DGND on L03_SIG1 (solid shape): 61.27,22.6 61.38,22.62 61.44,22.53 61.44,20.22 61.1,19.89 60.99,19.86 60.93,19.96 60.93,22.27
DGND on L03_SIG1 (solid shape): 64.88,28.83 64.94,28.84 64.97,28.79 64.97,26.13 64.76,25.92 64.65,25.9 64.58,25.99 64.58,26.8 64.82,27.04 64.82,28.77
DGND on L03_SIG1 (solid shape): 72.83,39.93 72.92,39.87 72.9,39.76 72.54,39.41 69.94,39.41 69.85,39.47 69.87,39.58 70.22,39.93
DGND on L03_SIG1 (solid shape): 96.15,25.92 96.21,26.02 96.32,25.99 96.66,25.66 96.66,22.95 96.59,22.86 96.48,22.88 96.15,23.22
DGND on L03_SIG1 (solid shape): 97.35,15.57 97.41,15.58 97.44,15.54 97.44,14.55 98.19,13.8 98.19,13.49 98.13,13.39 98.02,13.41 97.29,14.14 97.29,15.51
DGND on L03_SIG1 (solid shape): 59.75,31.7 59.86,31.72 59.92,31.63 59.92,31.43 59.57,31.07 59.57,29.34 58.68,28.45 58.1,28.45 57.83,28.17 57.77,28.22 57.78,28.28 57.78,28.34 58.62,29.18 58.62,30.57
DGND on L03_SIG1 (solid shape): 87.06,48.83 87.13,48.92 87.24,48.9 87.6,48.54 87.6,47.15 86.8,46.36 86.69,46.34 86.63,46.43 86.63,46.82 87.06,47.25
DGND on L03_SIG1 (solid shape): 89.41,45.14 89.5,45.08 89.48,44.96 89.42,44.91 89.42,41.46 88.3,40.33 88.19,40.31 88.12,40.4 88.12,44.24 89.02,45.14
DGND on L03_SIG1 (solid shape): 90.06,13.3 90.13,13.39 90.24,13.37 90.61,12.99 90.61,12.55 90.3,12.23 90.3,9.93 90.23,9.83 90.12,9.85 90.06,9.92
DGND on L03_SIG1 (solid shape): 104.47,44.39 104.57,44.32 104.54,44.21 103.64,43.31 103.64,38.91 101.48,36.74 101.42,36.73 101.39,36.78 101.39,36.82 103.18,38.61 103.18,43.16 104.41,44.39
DGND on L03_SIG1 (solid shape): 70.24,45.31 70.35,45.33 70.41,45.23 70.41,45.2 70.77,44.84 70.39,44.46 69.66,44.46 67.81,42.61 67.73,42.58 67.65,42.62 67.63,42.65 67.63,42.7
DGND on L03_SIG1 (solid shape): 47.98,32.23 48.08,32.17 48.05,32.06 47.89,31.9 47.51,31.9 46.12,30.51 46.12,29.29 46,29.17 45.89,29.15 45.83,29.24 45.83,30.78 47.28,32.23
DGND on L03_SIG1 (solid shape): 89.38,48.84 89.44,48.93 89.55,48.91 89.78,48.68 89.78,46.24 89.45,45.91 88.7,45.91 87.74,44.96 87.63,44.93 87.57,45.03 87.57,45.55 89.38,47.36
DGND on L03_SIG1 (solid shape): 96.97,13.52 97.03,13.61 97.14,13.59 97.92,12.81 97.92,9.12 98.26,8.78 98.26,8.56 98.19,8.47 98.08,8.49 97.59,8.98 97.59,12.41 96.97,13.04
DGND on L03_SIG1 (solid shape): 59.33,9.52 59.44,9.54 59.5,9.45 59.5,9.01 57.14,6.65 57.04,6.62 56.97,6.7 56.92,6.81 56.85,6.9 56.85,7.04
DGND on L03_SIG1 (solid shape): 60.84,39.6 60.9,39.69 61.02,39.67 61.25,39.44 62.66,39.44 62.72,39.38 62.72,37.32 63.08,36.96 63.07,36.93 63.05,36.87 63.05,36.8 63.03,36.72 62.95,36.69 62.46,36.69 62.42,36.73 62.42,37.16 62.09,37.49 60.91,37.49 60.84,37.56
DGND on L03_SIG1 (solid shape): 90.96,28.41 91.01,28.42 91.04,28.37 91.04,27.2 94.19,24.06 94.58,24.06 94.8,24.28 94.83,24.31 94.86,24.37 94.94,24.37 94.94,23.2 94.88,23.1 94.77,23.13 90.32,27.57 90.32,28.3 90.74,28.3 90.84,28.32 90.92,28.37
DGND on L03_SIG1 (solid shape): 55.73,18.83 55.84,18.86 55.9,18.76 55.9,18.32 54.8,17.22 54.8,16.5 54.68,16.32 54.68,16.11 54.66,16.02 54.58,15.98 51.46,15.98 51.37,16.04 51.39,16.15 53.6,18.36 55.25,18.36
DGND on L03_SIG1 (solid shape): 47.51,26.84 47.62,26.86 47.69,26.77 47.69,24.93 47.64,24.85 47.54,24.84 47.17,24.82 47,24.49 47,24.47 46.65,24.12 46.65,22.47 43.27,19.1 43.16,19.07 43.1,19.17 43.1,22.43
DGND on L03_SIG1 (solid shape): 80.74,40.73 80.85,40.76 80.91,40.66 80.91,40.54 81.19,40.26 81.92,40.26 81.92,39.65 81.5,39.22 81.18,39.54 81.1,39.54 81.1,39.6 81.1,39.62 80.76,40.17 80.43,39.62 80.43,39.6 80.43,39.54 80.26,39.54 80.26,40.25
DGND on L03_SIG1 (solid shape): 80.84,44.03 80.84,43.28 80.8,43.2 80.72,43.18 80.26,42.92 80.5,42.45 80.57,42.38 80.54,42.29 79.74,41.48 79.62,41.46 79.56,41.55 79.56,41.61 79.31,41.87 78.85,41.87 78.85,42.31 80.65,44.11 80.65,44.13 80.71,44.16
DGND on L03_SIG1 (solid shape): 82.78,44.8 82.85,44.9 82.96,44.86 83.81,44.42 84.65,44.86 84.77,44.9 84.84,44.8 84.84,43.5 83.28,41.94 83.28,36.53 83.21,36.43 83.1,36.45 83.08,36.48 82.78,36.48
DGND on L03_SIG1 (solid shape): 59.65,19.95 59.65,19.01 57.67,17.03 57.66,17.02 57.63,17 57.6,17 57.57,17 57.54,17.01 57.52,17.03 57.51,17.06 57.5,17.09 57.5,17.1 57.5,18.86 57.94,19.3 58.74,19.3 58.74,19.24 58.76,19.19 58.78,19.14 58.8,19.09 58.84,19.04 58.88,19.01 58.92,18.97 58.97,18.95 59.03,18.93 59.08,18.92 59.14,18.92 59.19,18.92 59.25,18.94 59.3,18.96 59.34,18.99 59.39,19.02 59.42,19.07 59.45,19.11 59.48,19.16 59.49,19.22 59.5,19.27 59.5,19.33 59.49,19.38 59.48,19.44 59.45,19.49 59.42,19.53 59.39,19.57 59.34,19.61 59.3,19.64 59.25,19.66 59.19,19.67 59.14,19.68 59.08,19.68 59.03,19.67 58.97,19.65 58.92,19.62 58.88,19.59 58.84,19.55 58.8,19.51 58.78,19.46 58.76,19.41 58.74,19.35 58.74,19.3 57.94,19.3 59.12,20.48
DGND on L03_SIG1 (solid shape): 31.61,15.19 31.66,15.16 31.65,15.1 31.18,14.63 31.18,10.69 30.59,10.1 30.48,10.08 30.41,10.17 30.41,12.09 30.45,12.16 30.53,12.19 30.98,12.56 30.53,12.94 30.45,12.96 30.41,13.04 30.41,14.13 31.47,15.19
DGND on L03_SIG1 (solid shape): 83.38,30.34 83.46,30.33 83.59,30.3 83.74,30.32 83.83,30.31 83.87,30.22 83.87,21.2 83.81,21.11 83.7,21.13 83.4,21.43 83.4,28.29 82.78,28.92 82.78,29.12 82.98,29.12 83.07,29.14 83.15,29.19 83.29,29.33 83.34,29.41 83.36,29.5 83.36,29.69 83.34,29.79 83.29,29.87 83.14,30.02 83.12,30.06 83.14,30.09 83.15,30.11 83.29,30.24 83.31,30.26 83.33,30.29
DGND on L03_SIG1 (solid shape): 52.76,29.1 52.87,29.13 52.93,29.03 52.93,26.66 53.21,26.38 53.21,26.36 53.27,26.15 53.44,26 53.5,25.93 53.48,25.84 53.08,25.44 52.42,25.44 51.71,24.73 51.6,24.71 51.54,24.81 51.54,25.9 51.58,25.99 51.68,26 52.03,26.04 52.19,26.36 52.19,26.38 52.49,26.68 52.49,28.84
DGND on L03_SIG1 (solid shape): 28.43,8.76 28.6,8.64 28.81,8.63 28.89,8.62 28.93,8.54 28.93,7.03 28.89,6.95 28.79,6.94 28.43,6.91 28.26,6.58 28.26,6.56 28.17,6.48 28.12,6.47 28.09,6.51 28.09,6.91 27.42,7.58 27.42,7.6 27.38,7.78 27.26,7.92 27.22,7.99 27.25,8.07 27.94,8.76
DGND on L03_SIG1 (solid shape): 93.15,37.93 93.26,37.95 93.32,37.86 93.32,35.02 93.39,34.96 93.41,34.85 93.31,34.79 93.29,34.79 93.09,34.58 93.03,34.5 93.02,34.4 93.02,34.21 93.03,34.12 93.09,34.04 93.27,33.85 93.11,33.69 93.06,33.61 93.04,33.52 93.04,33.17 93.29,32.92 93.31,32.92 93.41,32.85 93.39,32.74 93.32,32.68 93.32,31.93 94.34,30.91 93.95,30.53 93.89,30.43 93.78,30.46 92.68,31.55 92.68,37.46
DGND on L03_SIG1 (solid shape): 30.95,15.61 30.99,15.57 31.03,15.5 31,15.42 29.92,14.34 29.92,6.93 29.98,6.87 29.95,6.84 29.87,6.51 30.08,6.25 30.11,6.23 30.11,5.46 31.28,4.28 31.3,4.17 31.21,4.11 28.78,4.11 28.46,4.43 28.46,5.1 28.5,5.18 28.58,5.2 28.89,5.29 29.02,5.58 29.02,5.6 29.43,6.01 29.43,11.89 29.43,11.9 29.43,12.46 29.43,12.46 29.43,14.28 30.76,15.61
DGND on L03_SIG1 (solid shape): 33.17,6.68 33.28,6.7 33.34,6.61 33.34,5.79 33.62,5.51 33.62,4.91 33.58,4.83 33.5,4.81 33.31,4.79 33.15,4.68 32.51,4.68 32.35,4.52 31.75,4.52 30.9,5.37 30.88,5.46 30.94,5.53 31.01,5.57 31.07,5.63 31.4,5.63 31.47,5.6 31.5,5.51 31.95,5.07 32.2,5.65 32.17,5.68
DGND on L03_SIG1 (solid shape): 45.78,41.4 45.82,41.42 45.85,41.4 45.93,41.35 46.02,41.34 46.29,41.34 46.31,41.31 46.33,41.28 46.41,41.2 46.49,41.15 46.59,41.13 46.65,41.13 46.65,41.07 46.67,40.97 46.72,40.89 46.8,40.81 46.88,40.76 46.98,40.74 47.04,40.74 47.04,40.64 47.02,40.55 46.94,40.52 46.72,40.52 46.56,40.36 46.49,40.33 46.33,40.44 46.25,40.49 46.15,40.51 46.1,40.51 46.1,40.57 46.08,40.67 46.02,40.75 45.94,40.83 45.86,40.88 45.77,40.9 45.71,40.9 45.71,40.99 45.69,41.09 45.64,41.17 45.59,41.21
DGND on L03_SIG1 (solid shape): 106.26,34.89 106.31,34.98 106.41,34.97 106.51,34.93 106.62,34.92 106.64,34.92 106.96,34.6 106.96,29.81 107.64,29.13 107.64,29.11 107.73,28.86 107.95,28.73 108.03,28.66 108.01,28.56 107.43,27.98 105.35,27.98 103.95,26.58 103.84,26.56 103.78,26.65 103.78,26.84 102.06,28.56 102.06,33.97 102.78,34.7 102.89,34.72 102.96,34.63 102.96,33.54 104.35,33.54 104.68,33.36 105,33.54 106.26,33.54
DGND on L03_SIG1 (solid shape): 35.05,15.91 35.05,10.83 34.01,9.79 33.9,9.77 33.84,9.86 33.84,11.2 34.09,11.44 34.09,11.89 34.17,12.37 33.7,12.54 33.61,12.55 33.56,12.63 33.56,14.66 34.38,15.48 34.41,15.48 34.76,16.03 34.11,16.1 34.03,16.06 33.95,16.1 33.9,16.15 33.9,16.2 34.1,16.4 34.56,16.4
DGND on L03_SIG1 (solid shape): 61.77,33.3 61.81,33.3 61.89,33.28 61.92,33.2 61.92,28.37 61.79,28.06 61.95,27.77 61.99,27.7 61.96,27.62 61.52,27.18 60.38,27.18 59.82,26.63 59.82,26.07 59.03,25.28 57.93,25.28 57.3,24.66 57.19,24.64 57.13,24.73 57.13,25.68 59.03,27.58 59.14,27.6 59.21,27.51 59.21,27.17 58.7,26.66 58.4,26.01 59.05,26.31 59.71,26.96 59.71,27.65 61.62,29.57 61.62,33.2 61.65,33.28 61.73,33.3
DGND on L03_SIG1 (solid shape): 81.2,34.2 81.26,34.21 81.29,34.17 81.29,34.02 81.31,33.92 81.36,33.84 81.51,33.69 81.53,33.65 81.51,33.62 81.5,33.6 81.36,33.47 81.31,33.39 81.29,33.29 81.29,33.1 81.31,33.01 81.36,32.93 81.51,32.78 81.53,32.74 81.51,32.7 81.5,32.69 81.36,32.56 81.31,32.47 81.29,32.38 81.29,32.19 81.31,32.09 81.36,32.01 81.51,31.86 81.53,31.82 81.51,31.79 81.5,31.77 81.36,31.64 81.31,31.56 81.29,31.46 81.29,31.28 81.31,31.18 81.36,31.1 81.51,30.95 81.53,30.91 81.51,30.87 81.5,30.86 81.36,30.73 81.31,30.65 81.29,30.55 81.29,30.36 81.31,30.27 81.36,30.18 81.55,30 81.29,29.74 81.29,29.66 81.23,29.56 81.12,29.59 81.01,29.69 81.01,32.35 80.26,33.1 80.26,34.16 81.16,34.16
DGND on L03_SIG1 (solid shape): 60.42,36.24 60.48,36.34 60.6,36.32 60.74,36.17 61.1,36.17 61.14,36.13 61.14,35.77 61.5,35.41 61.49,35.38 61.52,35.02 61.86,34.91 61.92,34.91 61.92,34.75 61.86,34.75 61.58,34.69 61.45,34.43 61.45,34.41 61.4,34.36 61.31,34.45 61.31,34.47 61.2,34.68 60.99,34.76 60.96,34.76 60.91,34.81 61,34.9 61.02,34.9 61.21,35.46 60.65,35.27 60.65,35.25 60.6,35.2 60.48,35.17 60.42,35.27
DGND on L03_SIG1 (solid shape): 111.12,51.94 111.23,51.96 111.29,51.86 111.91,50.79 113.14,50.97 113.25,50.99 113.31,50.89 113.31,50.13 113.25,50.04 113.14,50.05 111.29,49.24 113.14,48.43 113.25,48.45 113.31,48.35 113.31,45.87 112.74,45.3 111.88,45.3 110.99,44.4 110.88,44.38 110.82,44.48 110.82,51.63
DGND on L03_SIG1 (solid shape): 22.3,16.18 22.38,16.13 22.39,16.03 22.35,15.79 22.48,15.57 22.48,14.67 22.44,14.63 22.36,14.6 22.29,14.65 21.61,14.59 22.06,14.08 22.15,14.06 22.19,13.98 22.19,11.06 20.34,9.21 20.34,4.85 20.31,4.8 20.25,4.81 20.16,4.91 20.16,9.33 21.19,10.36 21.19,11.49 21.04,11.63 21.02,11.74 21.09,11.81 21.39,12.25 20.95,12.55 20.86,12.58 20.83,12.65 20.83,15.4 20.87,15.49 20.96,15.5 21.3,15.56 21.46,15.87 21.46,15.89 21.74,16.18
DGND on L03_SIG1 (solid shape): 97.73,27.52 97.73,25.36 98.75,24.35 98.77,24.25 98.69,24.18 98.5,23.53 99.14,23.73 99.21,23.8 99.31,23.78 99.57,23.52 99.57,20.95 99.51,20.85 99.4,20.87 97.46,22.81 97.46,23.36 97.51,23.44 97.6,23.45 98.13,23.8 97.6,24.15 97.51,24.16 97.46,24.25 97.46,24.28 97.5,24.36 97.58,24.38 98.04,24.75 97.58,25.13 97.5,25.15 97.46,25.23 97.46,26.77 97.14,27.09 97.12,27.2 97.21,27.27 97.6,27.65
DGND on L03_SIG1 (solid shape): 86.9,43.59 87.01,43.61 87.07,43.52 87.07,34.02 86.04,32.99 85.93,32.97 85.87,33.07 85.87,33.91 85.92,34 86.02,34 86.61,34.32 86.02,34.65 85.92,34.64 85.87,34.73 85.87,34.88 85.92,34.97 86.02,34.96 86.61,35.29 86.02,35.61 85.92,35.61 85.87,35.7 85.87,35.97 85.92,36.06 86.02,36.06 86.61,36.38 86.02,36.7 85.92,36.7 85.87,36.79 85.87,42.56
DGND on L03_SIG1 (solid shape): outline of 83 points within 60.77,31.9 65.92,36.99
DGND on L03_SIG1 (solid shape): outline of 96 points within 55.24,33.56 59.52,46.5
DGND on L08_SIG2 (solid shape): 103.34,26.96 102.56,26.18 102.45,26.16 102.39,26.26 102.39,29.07 102.9,29.59 103.34,29.59
DGND on L08_SIG2 (solid shape): 106.52,45.2 106.58,45.3 106.69,45.27 107.76,44.21 107.76,38.71 107.49,38.44 107.25,38.68 107.25,44.32 106.52,45.05
DGND on L08_SIG2 (solid shape): 35.13,17.94 35.17,17.89 33.82,16.54 31.38,16.54 31.28,16.6 31.3,16.71 31.65,17.06 34.15,17.06 35.07,17.97
DGND on L08_SIG2 (solid shape): 62.33,32.61 62.33,31.98 60.72,30.37 60.18,30.37 60.09,30.43 60.11,30.54 62.26,32.69
DGND on L08_SIG2 (solid shape): 23.88,15.72 23.88,14.6 24.46,14.03 24.46,13.18 24.4,13.09 24.29,13.11 23.72,13.68 23.72,15.37 23.74,15.39 23.74,15.57 23.81,15.65 23.85,15.75
DGND on L08_SIG2 (solid shape): 30.17,8.72 30.21,8.69 30.2,8.64 28.92,7.36 28.24,7.36 27.81,7.79 27.79,7.9 27.88,7.96 29.32,7.96 30.08,8.72
DGND on L08_SIG2 (solid shape): 35.24,15.73 35.35,15.75 35.41,15.66 35.41,14.68 34.79,14.06 33.81,14.06 32.14,12.38 32.01,12.38 31.96,12.41 31.97,12.47
DGND on L08_SIG2 (solid shape): 46.49,30.92 46.58,30.86 46.56,30.75 45.86,30.05 43.13,30.05 43.03,30.11 43.06,30.22 43.76,30.92
DGND on L08_SIG2 (solid shape): 47.87,19.07 47.97,19 47.95,18.89 47.45,18.39 43.49,18.39 43.39,18.45 43.42,18.57 43.92,19.07
DGND on L08_SIG2 (solid shape): 98.9,11.66 98.9,11.17 98.84,11.07 98.73,11.09 97.05,12.77 97.03,12.88 97.12,12.94 97.62,12.94
DGND on L08_SIG2 (solid shape): 99.77,13.94 99.79,13.83 99.7,13.77 99.33,13.77 98.03,15.07 98.01,15.18 98.1,15.25 98.46,15.25
DGND on L08_SIG2 (solid shape): 104.34,30.01 104.45,30.03 104.51,29.94 104.51,27.69 104.01,27.19 103.9,27.16 103.84,27.26 103.84,29.5
DGND on L08_SIG2 (solid shape): 63.76,31.15 63.87,31.17 63.93,31.08 63.93,31.03 59.99,27.09 59.7,27.09 59.61,27.15 59.63,27.26 60.9,28.53 61.14,28.53
DGND on L08_SIG2 (solid shape): 14.69,32.54 14.8,32.56 14.87,32.47 14.87,28.19 14.07,27.39 14.07,23.3 14.04,23.25 13.98,23.26 13.96,23.28 13.96,26.89 13.06,27.78 13.06,31.48 13.59,32 14.16,32
DGND on L08_SIG2 (solid shape): 64.52,12.79 64.63,12.81 64.69,12.71 64.69,10.64 64.23,10.18 64.19,10.18 64.11,10.22 64.09,10.31 64.1,10.35 64.1,10.42 64.23,10.55 64.23,12.5
DGND on L08_SIG2 (solid shape): 66.47,28.71 66.51,28.63 66.51,27.56 65.68,26.74 65.61,26.73 65.56,26.73 65.47,26.74 65.44,26.82 65.44,27.86 66.3,28.73 66.39,28.73
DGND on L08_SIG2 (solid shape): 57.03,29.32 57.03,29.3 57.04,29.24 57.05,29.18 57.03,29.09 56.95,29.05 56.78,29.05 56.61,28.88 55.04,28.88 54.95,28.94 54.97,29.05 55.42,29.5 56.85,29.5
DGND on L08_SIG2 (solid shape): 37.77,15.3 37.82,15.38 37.92,15.39 38.02,15.36 38.14,15.36 38.22,15.34 38.25,15.26 38.25,14.03 33.45,9.22 33.12,9.22 33.02,9.29 33.05,9.4 37.77,14.12
DGND on L08_SIG2 (solid shape): 54.95,32.97 55.03,32.94 55.05,32.86 55.05,32.79 55.07,32.73 55.05,32.64 54.97,32.6 54.12,32.6 53.49,31.96 49.58,31.96 49.49,32.03 49.51,32.14 50.04,32.67 53,32.67 53.31,32.97
DGND on L08_SIG2 (solid shape): 76.15,38.37 76.21,38.46 76.32,38.44 76.64,38.12 76.64,35.46 77.37,34.73 77.4,34.64 77.35,34.56 77.25,34.49 77.18,34.39 77.1,34.34 77.02,34.37 76.15,35.23
DGND on L08_SIG2 (solid shape): 82.04,24.58 82.15,24.6 82.22,24.51 82.22,16.63 84.35,14.5 90.87,14.5 91.3,14.06 91.33,13.95 91.23,13.88 78.9,13.88 78.81,13.95 78.83,14.06 81.04,16.27 81.04,23.58
DGND on L08_SIG2 (solid shape): 40.38,44.7 41.99,44.7 42.19,44.89 42.3,44.91 42.36,44.82 42.36,42.6 41.97,42.2 39.93,42.2 39.53,42.61 39.53,44.62 39.65,44.83 39.62,45.08 39.62,45.18 39.71,45.23 39.85,45.23
DGND on L08_SIG2 (solid shape): 33.32,11.14 33.41,11.08 33.39,10.96 32.51,10.08 29.44,10.08 28.74,9.38 28.72,9.39 28.55,9.35 28.41,9.23 28.33,9.19 28.25,9.22 26.5,10.96 26.48,11.08 26.58,11.14
DGND on L08_SIG2 (solid shape): 68.82,22.6 68.82,20.09 68.76,20 68.65,20.01 67.94,20.27 67.24,19.99 67.13,19.97 67.07,20.06 67.07,22.13 68.13,23.19 68.13,23.2 68.2,23.23
DGND on L08_SIG2 (solid shape): 60.01,29.87 60.11,29.81 60.08,29.69 59.44,29.05 57.88,29.05 57.79,29.09 57.78,29.18 57.72,29.52 57.41,29.67 57.39,29.67 57.36,29.69 57.34,29.81 57.44,29.87
DGND on L08_SIG2 (solid shape): 72,22.65 72,20.01 71.93,19.91 71.82,19.94 71.01,20.27 70.23,19.88 70.12,19.85 70.05,19.94 70.05,22.39 71.16,23.5
DGND on L08_SIG2 (solid shape): 25.7,10.82 25.76,10.91 25.87,10.89 28.13,8.63 28.15,8.52 28.06,8.46 27.77,8.46 27.05,9.19 27.05,9.21 26.4,9.48 26.67,8.83 26.69,8.83 27.07,8.46 27.09,8.35 27,8.28 26.52,8.28 25.7,9.1
DGND on L08_SIG2 (solid shape): 79.65,23.63 79.66,23.65 79.68,23.66 79.71,23.67 79.74,23.66 79.77,23.65 79.79,23.63 79.81,23.61 79.82,23.58 79.82,23.56 79.82,16.56 77.9,14.64 75.12,14.64 75.1,14.64 75.07,14.65 75.05,14.67 75.03,14.69 75.02,14.72 75.01,14.75 75.02,14.78 75.03,14.8 75.04,14.81 75.53,15.3 76.86,15.3 76.86,15.25 76.87,15.19 76.89,15.14 76.92,15.09 76.95,15.05 76.99,15.01 77.04,14.98 77.09,14.95 77.14,14.93 77.19,14.92 77.25,14.92 77.31,14.93 77.36,14.94 77.41,14.96 77.46,14.99 77.5,15.03 77.54,15.07 77.57,15.12 77.59,15.17 77.61,15.22 77.62,15.28 77.62,15.33 77.61,15.39 77.59,15.44 77.57,15.49 77.54,15.54 77.5,15.58 77.46,15.61 77.41,15.64 77.36,15.66 77.31,15.68 77.25,15.68 77.19,15.68 77.14,15.67 77.09,15.65 77.04,15.63 76.99,15.6 76.95,15.56 76.92,15.51 76.89,15.47 76.87,15.41 76.86,15.36 76.86,15.3 75.53,15.3 77.46,17.23 77.46,21.45
DGND on L08_SIG2 (solid shape): 88.17,29.06 88.2,28.97 88.13,28.9 87.99,28.27 88.62,28.41 88.69,28.47 88.79,28.45 93.8,23.43 93.8,19.34 93.76,19.26 93.67,19.25 93.57,19.26 93.48,19.26 93.4,19.28 93.36,19.36 93.36,22.29 84.83,30.82 84.83,31.77 85.46,31.77
DGND on L08_SIG2 (solid shape): 64.98,7.07 65.1,7.09 65.16,7 65.16,4.83 64.44,4.11 64.33,4.08 64.26,4.18 64.26,5.18 64.32,5.27 64.42,5.26 65.02,5.58 64.42,5.89 64.32,5.88 64.26,5.97 64.26,6.35
DGND on L08_SIG2 (solid shape): 35.6,14.17 35.71,14.19 35.78,14.1 35.78,13.87 34.3,12.39 34.22,12.36 34.15,12.4 33.57,12.45 33.61,11.87 33.66,11.8 33.63,11.72 33.55,11.64 28.47,11.64 28.37,11.7 28.39,11.81 28.49,11.91 28.53,11.88 28.77,11.8 29,11.89 29.04,11.92 29.07,11.88 32.34,11.88 34.02,13.56 35,13.56
DGND on L08_SIG2 (solid shape): 36.24,30.24 36.34,30.18 36.31,30.07 29.08,22.84 29.08,17.03 28.95,16.69 29.17,16.4 29.23,16.33 29.2,16.24 29.03,16.07 28.95,16.04 28.88,16.09 28.74,16.2 28.56,16.24 28.54,16.24 28.38,16.41 28.38,23.29 32.04,26.95 32.12,26.98 32.2,26.94 32.63,26.8 32.89,27.17 32.89,27.19 35.94,30.24
DGND on L08_SIG2 (solid shape): 78.73,45.71 78.8,45.81 78.91,45.79 79.86,44.83 79.86,44.53 79.5,44.53 79.29,44.32 79.24,44.24 79.22,44.15 79.22,43.85 79.42,43.65 79.48,43.59 79.29,43.41 79.24,43.33 79.22,43.23 79.22,43.04 79.24,42.95 79.29,42.87 79.42,42.73 79.48,42.68 79.29,42.49 79.24,42.41 79.22,42.32 79.22,42.13 79.24,42.03 79.29,41.95 79.42,41.82 79.48,41.77 79.29,41.58 79.24,41.5 79.22,41.4 79.22,41.21 79.24,41.12 79.29,41.04 79.42,40.9 79.5,40.85 79.6,40.83 79.86,40.83 79.86,39.87 79.8,39.77 79.69,39.79 78.73,40.75
DGND on L08_SIG2 (solid shape): 66.77,16.41 66.82,16.38 66.81,16.32 66.74,16.25 65,16.25 59.6,10.85 59.6,8.07 61.06,6.62 61.06,6.56 61.06,6.53 61.05,6.47 61.02,6.43 60.22,6.43 60.19,6.46 60.19,6.46 59.97,6.81 59.45,6.73 59.39,6.82 59.39,7.02 58.81,7.59 58.81,11.33 63.4,15.92 63.48,15.95 63.55,15.91 64.04,15.8 64.22,16.27 64.23,16.36 64.31,16.41
DGND on L08_SIG2 (solid shape): 54.38,11.17 54.47,11.11 54.45,11 50.75,7.3 50.67,7.3 50.59,7.35 50.58,7.44 50.58,7.77 50.32,7.98 50.25,8.05 50.27,8.15 52.55,10.43 52.65,10.45 52.72,10.37 53.37,10.17 53.16,10.82 53.08,10.88 53.11,10.99 53.29,11.17
DGND on L08_SIG2 (solid shape): 27.02,32.83 27.11,32.78 27.11,32.68 27.05,32.42 27.18,32.18 27.18,31.84 28.86,30.15 28.89,30.04 28.79,29.98 26.95,29.98 26.86,30.03 26.86,30.14 26.54,30.72 26.22,30.14 26.22,30.03 26.13,29.98 26.05,29.98 24.56,28.49 24.45,28.47 24.39,28.57 24.39,30.43 26.8,32.83
DGND on L08_SIG2 (solid shape): 65.49,30.22 65.56,30.31 65.67,30.29 66.3,29.65 66.33,29.55 66.25,29.48 66.03,29.35 65.95,29.1 65.95,29.08 64.94,28.07 64.94,26.28 63.93,25.27 61.98,25.27 61.88,25.34 61.91,25.45 64.15,27.69 64.15,28.78 64.64,29.26 64.7,29.26 64.8,29.2 64.78,29.09 64.28,28.59 64.28,27.12 63.9,26.74 63.88,26.74 63.61,26.09 64.26,26.36 64.26,26.38 64.78,26.91 64.78,28.39 65.49,29.1
DGND on L08_SIG2 (solid shape): 80.38,42.49 80.45,42.48 80.58,42.44 80.71,42.44 80.8,42.42 80.84,42.34 80.84,41.48 82.43,39.9 82.43,37.98 82.36,37.89 82.25,37.91 80.89,39.28 80.86,39.37 80.92,39.44 81.09,39.99 80.53,40.09 80.42,40.08 80.36,40.17 80.36,40.95 80.34,41.04 80.29,41.12 80.14,41.27 80.12,41.31 80.14,41.35 80.16,41.36 80.29,41.49 80.34,41.58 80.36,41.67 80.36,41.86 80.34,41.96 80.29,42.04 80.14,42.19 80.12,42.23 80.14,42.26 80.16,42.28 80.29,42.41 80.32,42.44
DGND on L08_SIG2 (solid shape): 40.03,33.09 40.11,33.04 40.12,32.94 40.47,32.41 40.82,32.94 40.82,33.04 40.91,33.09 48.32,33.09 48.41,33.02 48.39,32.91 48.2,32.72 41.44,32.72 39.84,31.12 38.75,31.12 38.67,31.17 38.66,31.26 38.67,31.48 38.55,31.67 38.55,32.32 38.93,32.7 39.02,32.73 39.09,32.66 39.59,32.44 39.8,32.94 39.81,33.04 39.89,33.09
DGND on L08_SIG2 (solid shape): 62.58,28.97 62.69,28.99 62.75,28.9 62.75,27.72 61.08,26.04 60.99,26.04 60.91,26.09 60.89,26.18 60.58,26.61 60.27,26.18 60.25,26.09 60.17,26.04 59.08,26.04 59,26.09 58.99,26.18 59,26.31 58.97,26.44 58.97,26.54 59.05,26.59 60.19,26.59 61.63,28.03 61.73,28.05 61.8,27.98 62.44,27.81 62.27,28.45 62.2,28.52 62.22,28.62
DGND on L08_SIG2 (solid shape): 86.25,28.24 86.33,28.21 91.92,22.62 91.92,19.91 91.86,19.82 91.75,19.84 91.23,20.36 91.23,20.37 91.42,20.56 91.48,20.64 91.49,20.74 91.49,20.93 91.48,21.02 91.42,21.11 91.29,21.24 91.21,21.29 91.11,21.31 90.85,21.31 90.85,21.39 90.85,21.58 90.83,21.67 90.77,21.75 90.64,21.89 90.56,21.94 90.46,21.96 90.2,21.96 90.2,22.03 90.2,22.22 90.18,22.32 90.13,22.4 89.99,22.53 89.91,22.59 89.82,22.61 89.55,22.61 89.55,22.68 89.55,22.87 89.54,22.96 89.48,23.04 89.35,23.18 89.27,23.23 89.17,23.25 88.91,23.25 88.91,23.33 88.91,23.52 88.89,23.61 88.83,23.69 88.7,23.83 88.62,23.88 88.52,23.9 88.26,23.9 88.26,23.97 88.26,24.27 88.05,24.47 87.97,24.53 87.88,24.54 87.59,24.54 87.33,24.29 87.27,24.34 87.27,25.71 85.72,27.27 85.72,27.9 85.75,27.98 85.82,28 86.02,28.05 86.17,28.19
DGND on L08_SIG2 (solid shape): 57.35,36.17 57.43,36.14 57.45,36.06 57.78,35.7 58.11,36.06 58.14,36.14 58.21,36.17 58.95,36.17 59.03,36.14 59.05,36.06 59.05,36.02 59.05,35.98 59.03,35.9 58.95,35.87 58.32,35.87 57.96,35.51 57.93,35.53 57.58,35.49 57.46,35.15 57.46,35.09 57.3,35.09 57.3,35.15 56.78,35.49 56.98,34.9 57,34.9 57.05,34.85 56.96,34.76 56.94,34.76 56.75,34.66 56.65,34.47 56.65,34.45 56.56,34.36 56.51,34.41 56.51,34.43 56.14,34.76 55.86,34.35 55.86,34.29 55.7,34.29 55.71,34.44 55.7,34.53 55.69,34.56 56.04,34.91 56.04,36.09 56.12,36.17
DGND on L08_SIG2 (solid shape): 33.17,16.04 33.25,16 33.27,15.92 33.5,15.51 33.95,15.63 34.03,15.67 34.11,15.63 34.15,15.59 34.19,15.55 34.23,15.48 34.2,15.4 33.39,14.59 33.3,14.56 33.23,14.62 32.62,14.71 32.72,14.1 32.77,14.03 32.74,13.94 31.61,12.81 30.89,12.81 30.44,12.91 30.23,12.5 30.2,12.42 30.13,12.38 29.28,12.38 29.23,12.43 29.05,12.43 28.85,12.55 28.62,12.54 28.53,12.55 28.48,12.63 28.48,13.36 30.77,15.65 30.85,15.68 30.93,15.64 31.23,15.48 31.54,15.63 31.62,15.67 31.7,15.63 32.15,15.51 32.38,15.92 32.4,16 32.48,16.04
DGND on L08_SIG2 (solid shape): 73.49,29.28 73.6,29.3 73.66,29.21 73.66,29.03 74.31,28.39 74.33,28.3 74.28,28.22 74.18,27.61 74.79,27.71 74.86,27.77 74.95,27.74 75.17,27.52 75.17,26.16 75.12,26.07 75.02,26.07 74.42,25.76 75.02,25.44 75.12,25.44 75.17,25.35 75.17,21.69 75.1,21.59 74.99,21.62 74.22,22.05 73.4,21.74 73.29,21.72 73.23,21.82 73.23,22.65 74.16,23.58 74.16,26.13 73.21,27.08 73.21,27.42 73.25,27.5 73.34,27.51 73.81,27.88 73.34,28.25 73.25,28.27 73.21,28.35 73.21,29.01
DGND on L08_SIG2 (solid shape): 52.71,11.53 52.8,11.47 52.78,11.36 49.15,7.73 49.06,7.71 48.99,7.76 48.32,7.82 48.62,7.23 48.68,7.2 48.71,7.13 48.71,7.02 48.67,6.97 48.65,6.97 48.32,6.81 48.29,6.45 48.28,6.35 48.19,6.31 48.06,6.31 47.52,5.76 47.43,5.73 47.36,5.78 46.77,5.84 46.83,5.25 46.88,5.18 46.85,5.1 46.79,5.03 46.79,4.85 46.67,4.64 46.69,4.39 46.69,4.3 46.6,4.25 45.87,4.25 45.79,4.3 45.78,4.39 45.74,4.79 45.38,4.94 45.3,4.96 45.26,5.04 45.26,6.11 45.3,6.19 45.38,6.22 45.81,6.52 45.51,6.96 45.44,7.03 45.46,7.14 49.86,11.53
DGND on L08_SIG2 (solid shape): 63.05,45.65 63.05,45.63 63.17,45.38 63.51,45.28 63.54,45.2 63.54,45.14 63.49,45.14 63.48,45.15 63.05,44.86 63.43,44.5 63.51,44.48 63.54,44.4 63.54,42.86 63.51,42.78 63.43,42.76 63.05,42.38 63.53,42.13 63.56,42.15 63.94,41.77 64.55,41.77 64.63,41.74 64.65,41.66 64.65,41.6 64.63,41.52 64.55,41.49 61.72,41.49 61.64,41.57 61.64,42.8 61.67,42.88 61.75,42.9 62.11,43.25 61.7,43.55 61.64,43.55 61.64,43.71 61.7,43.71 62.11,44.03 61.7,44.35 61.64,44.35 61.64,44.51 61.7,44.51 61.97,44.56 62.11,44.79 62.11,44.81 62.2,44.9 62.25,44.85 62.25,44.83 62.83,44.62 62.53,45.16 62.45,45.18 62.42,45.26 62.42,45.32 62.48,45.32 62.48,45.31 62.76,45.35 62.91,45.59 62.91,45.61 63,45.7
DGND on L08_SIG2 (solid shape): outline of 235 points within 91.01,5.31 98.95,13.39
DGND on L08_SIG2 (solid shape): outline of 248 points within 20.25,23.6 32.73,29.48
DGND on L08_SIG2 (solid shape): outline of 267 points within 49.81,35.25 54.72,40.52
DGND on L08_SIG2 (solid shape): outline of 304 points within 83.23,15.55 89.82,27.85
DGND on L08_SIG2 (solid shape): outline of 352 points within 64.04,41.67 68.67,44.51
DGND on L08_SIG2 (solid shape): outline of 482 points within 38.98,2.55 71.18,14.62
DGND on L08_SIG2 (solid shape): outline of 671 points within 15.6,12.87 38.83,33.45
DGND on L08_SIG2 (solid shape): outline of 1355 points within 53.08,29.9 67.53,40.55
DGND on TOP: 68.71,98.92 68.71,97.27 75.69,97.27 75.69,98.92
DGND on TOP: 91.44,58.15 95.25,58.15 95.25,60.44 93.47,60.44 93.47,59.93 92.45,58.92 91.69,58.92 91.44,58.66
DGND on TOP: 90.42,28.09 90.42,27.01 90.84,27.01 90.84,27.94 91.85,28.94 92.59,28.94 92.71,29.06 92.71,30.17 92.9,30.37 95,30.37 95,30.94 94.99,30.95 93.82,30.95 93.59,31.18 93.59,31.45 93.05,31.99 92.81,31.99 92.61,31.8 91.84,31.8 91.84,30.62 91.62,30.4 90.96,30.4 90.96,28.64
DGND on TOP: 103.88,54.22 103.88,47.36 105.91,47.36 105.91,54.22
DGND on TOP: 96.77,46.47 96.77,44.31 98.29,44.31 98.29,46.47
DGND on TOP: 96.77,35.81 96.77,37.97 98.29,37.97 98.29,35.81
DGND on TOP: 96.39,12.39 99.56,12.39 99.56,15.86 96.77,15.86 96.13,16.5 95.88,16.5 95.88,15.23 96.39,14.72
DGND on TOP: 100.96,16.12 100.96,18.91 100.07,18.91 99.93,19.05 99.93,20.21 99.12,21.02 99.12,22.79 101.47,25.13 109.34,25.13 109.34,22.09 101.85,22.09 101.85,17.39 102.23,17.01 105.28,17.01 105.53,16.75 107.18,16.75 107.31,16.88 109.6,16.88 109.6,16.12
DGND on TOP: 108.71,53.33 108.71,47.87 110.74,47.87 110.74,53.33
DGND on BOTTOM: 101.21,25.24 101.21,22.47 105.79,22.47 105.79,25.24
DGND on BOTTOM: 90.18,14.71 90.18,12.43 98.84,12.43 98.84,14.71
DGND on BOTTOM: 99.06,48.25 99.06,47.23 100.33,47.23 100.33,49.01 100.07,49.26 100.07,56.12 97.28,56.12 97.28,50.03
DGND on BOTTOM: 91.05,36.56 91.05,34.4 98.42,34.4 98.42,36.6 92.82,36.6 92.68,36.74 92.68,37.37 92.65,37.39 91.89,37.39
DGND on BOTTOM: 70.86,42.15 70.86,37.96 72.26,37.96 72.26,42.15
DGND on BOTTOM: 101.09,30.24 101.09,27.92 108.33,27.92 108.33,33.9 101.34,33.9 101.34,30.49
DGND on BOTTOM: 98.93,44.56 98.93,36.69 111.25,36.69 111.25,44.56
DGND on BOTTOM: 52.19,81.52 52.19,80.63 53.84,80.63 54.73,79.74 54.73,77.97 54.99,77.71 56.68,77.71 58.56,79.59 61.84,79.59 62.47,80.22 62.47,81.36 61.38,82.45 61.38,82.9 61.11,83.17 58.03,83.17 56.38,81.52
DGND on BOTTOM: 103.75,43.17 105.66,43.17 105.66,54.22 103.75,54.22 103.75,47.99 103.37,47.61 103.37,43.55
DGND on BOTTOM: 22.35,76.06 22.35,73.01 27.81,73.01 27.81,76.06
DGND on L02_GND1, L09_GND4: 70.35,8.88 70.64,7.84 71.43,7.1 67.88,7.1 67.88,2.53 67.87,2.55 43.25,2.55 43.25,5.2 41.04,7.42 38.82,5.2 38.82,2.35 17.42,2.35 17.42,7.1 13.83,7.1 14.63,7.85 14.93,8.9 14.93,13.3 10.02,13.3 10.02,76.95 10.27,76.7 34.79,76.7 37.97,73.52 45.08,73.52 45.46,73.9 45.46,96.63 44.83,97.27 41.65,97.27 41.27,97.65 41.27,108.19 113.74,108.19 113.74,7.1 112.15,7.1 112.15,2.65 88.9,2.65 88.9,13.3 70.35,13.3
DGND on L04_GND2: 70.35,8.88 70.64,7.84 71.43,7.1 67.88,7.1 67.88,2.54 43.25,2.54 43.25,5.2 41.04,7.42 38.82,5.2 38.82,2.28 38.77,2.33 17.42,2.33 17.42,7.1 13.83,7.1 14.63,7.85 14.93,8.9 14.93,13.3 10.02,13.3 10.02,76.95 10.27,76.7 34.79,76.7 37.97,73.52 45.08,73.52 45.46,73.9 45.46,96.63 44.83,97.27 41.65,97.27 41.27,97.65 41.27,108.19 113.74,108.19 113.74,7.1 112.15,7.1 112.15,2.65 88.9,2.65 88.9,13.3 70.35,13.3
DGND on L07_GND3: 70.35,8.88 70.64,7.84 71.43,7.1 67.88,7.1 67.88,2.54 43.25,2.54 43.25,5.2 41.04,7.42 38.82,5.2 38.82,2.28 38.67,2.43 17.42,2.43 17.42,7.1 13.83,7.1 14.63,7.85 14.93,8.9 14.93,13.3 10.02,13.3 10.02,76.95 10.27,76.7 34.79,76.7 37.97,73.52 45.08,73.52 45.46,73.9 45.46,96.63 44.83,97.27 41.65,97.27 41.27,97.65 41.27,108.19 113.74,108.19 113.74,7.1 112.15,7.1 112.15,2.65 88.9,2.65 88.9,13.3 70.35,13.3
VBUS_MAIN on TOP: 100.83,17.13 100.83,18.15 98.8,18.15 98.55,18.4 98.55,18.91 97.98,19.48 97.98,22.12 99.06,23.19 99.06,24.12 98.67,24.5 97.91,24.5 96.52,23.1 96.52,18.15 96.26,17.89 95.37,17.89 95.37,17.51 98.04,17.51 98.14,17.42 99.53,17.42 99.81,17.13
VBUS_MAIN on L08_SIG2: 95.99,21.38 95.99,17.28 96.2,17.07 98.74,17.07 98.93,17.26 98.93,21.42 99.1,21.59 99.1,24 98.86,24.24 97.66,24.24 97.2,23.79 97.2,22.59
VBUS_USBC on TOP: 101.98,22.21 101.98,17.51 102.22,17.26 105.66,17.26 106.29,17.89 107.69,17.89 107.95,18.15 108.96,18.15 108.96,18.4 107.69,18.4 107.44,18.15 106.17,18.15 106.04,18.28 106.04,20.69 106.17,20.82 107.44,20.82 107.69,20.56 108.96,20.56 108.96,20.94 107.95,20.94 107.69,21.2 106.17,21.2 105.15,22.21
VBUS_USBC on BOTTOM: 101.98,22.22 101.98,18.15 105.41,18.15 105.41,21.72 104.9,22.22
VBUS_USBC on L06_PWR2: 93.93,14.03 93.93,8.88 106.42,8.88 106.42,24.37 97.4,24.37 97.15,24.12 97.15,17.26
VBUS_XDS110 on TOP: 12.44,95.87 12.44,96.89 14.22,96.89 14.22,100.32 17.78,100.32 17.78,97.02 16.63,95.87
VBUS_XDS110 on L06_PWR2: 22.22,83.68 22.22,104.38 16.63,104.38 14.35,102.1 14.35,84.19 16.25,82.28 20.82,82.28
VCC3V3_XDS on TOP: 18.16,97.65 22.98,97.65 22.98,100.32 18.16,100.32
VCC3V3_XDS on L05_PWR1: 10.02,77.85 10.02,108.19 40.64,108.19 40.64,97.02 41.02,96.63 44.32,96.63 44.57,96.38 44.57,74.41 38.86,74.41 35.49,77.77 10.09,77.77 ; 1 cut-out
VCC_1V2 on TOP: 81.18,50.52 81.18,46.94 84.45,46.94 84.45,50.52
VCC_1V2 on BOTTOM: 81.25,49.87 81.25,46.94 84.71,46.94 84.71,49.87
VCC_1V2 on L05_PWR1: 85.21,49.14 85.21,44.31 77.34,36.44 69.21,36.44 66.47,33.7 57.75,33.7 55.4,36.05 55.4,37.29 55.24,37.45 54.1,37.45 54.1,46.47 57.53,49.9 84.45,49.9 ; 1 cut-out
VCC_1V8_LDO4 on BOTTOM: 105.79,55.49 105.79,48.37 107.06,48.37 107.06,55.49
VCC_1V8_LDO4 on L06_PWR2: 38.86,23.61 38.86,22.09 49.91,22.09 53.46,25.64 53.46,28.69 54.1,29.32 91.94,29.32 98.03,35.42 110.2,35.42 111.6,34.02 113.53,34.02 113.53,45.2 108.96,49.77 106.29,49.77 105.53,49.01 105.53,48.28 88.68,31.43 72.08,31.43 71.02,30.37 53.11,30.37 46.35,23.61
VCC_5V0 on L06_PWR2: 64.38,4.05 67.18,4.05 67.18,7.73 66.04,8.88 20.19,8.88 19.3,9.77 19.3,19.04 16.12,22.21 16.12,23.74 17.01,24.63 21.46,24.63 24,22.09 25.01,22.09 25.27,22.34 25.27,25.39 24.76,25.9 15.36,25.9 14.22,24.75 14.22,15.48 16.51,13.2 16.51,9 17.9,7.61 41.98,7.61 45.5,4.09 64.35,4.09 64.38,4.06
VCC_6V0_BBOUT on TOP: 100.83,47.36 100.83,49.77 100.58,50.03 100.58,53.94 99.92,54.6 97.91,54.6 96.77,53.45 96.77,51.4 92.98,47.61 92.32,47.61 90.67,45.96 90.17,45.96 90.17,50.66 91.05,51.55 92.39,51.55 94.36,53.52 94.36,55.61 92.32,57.65 91.31,57.65 91.31,57.9 100.45,57.9 100.81,57.54 100.81,55.51 101.98,54.34 101.98,53.33 101.85,53.2 101.85,47.36
VCC_6V0_BBOUT on BOTTOM: 100.45,56.25 100.45,49.52 100.71,49.26 100.71,47.1 100.45,46.85 100.45,44.95 101.34,44.95 101.34,46.09 101.91,46.66 101.91,56.25
VCC_PLDO1 on BOTTOM: 107.18,36.18 107.18,33.13 109.34,33.13 111.25,35.04 111.25,36.18
VCC_PLDO2 on TOP: 106.55,53.07 106.55,45.2 108.33,45.2 108.33,53.07
VCC_PLDO2 on BOTTOM: 107.56,51.3 107.56,48.25 109.34,48.25 109.34,50.15 112.77,50.15 113.41,50.79 113.41,52.72 113.2,52.93 111.49,52.93 110.88,52.31 108.58,52.31
VDD1V1A on L06_PWR2: 83.94,78.47 83.94,68.19 94.23,68.19 94.23,70.6 89.66,75.17 89.53,75.17 86.23,78.47
VDD2V5A on TOP: 91.82,73.88 91.82,66.92 94.48,66.92 94.48,73.88
VDD_2V5 on TOP: 69.27,89.4 69.27,88 71.24,88 71.37,88.13 72.77,88.13 72.77,88.76 71.88,88.76 71.24,89.4
VDD_2V5 on TOP: 93.09,76.31 93.09,74.28 96.13,74.28 96.13,76.31
VDD_2V5 on TOP: 101.34,83.77 101.34,81.2 102.89,81.2 105.41,83.71 105.41,87.5 102.62,87.5 102.62,84.44 101.95,83.77
VDD_2V5 on BOTTOM: 100.84,86.37 100.84,80.31 103.98,80.31 103.98,85 104.89,85.92 104.89,87.36 102.7,87.36 101.71,86.37
VDD_2V5 on L05_PWR1: 87.24,73.52 76.07,84.7 69.21,84.7 69.21,89.4 76.96,89.4 79.37,86.98 79.37,85.17 82.47,82.07 85.36,82.07 88.96,78.47 95.88,78.47 95.88,73.52 ; 1 cut-out
VDD_2V5 on L06_PWR2: 96.9,74.19 105.38,82.67 105.38,89.93 102.48,92.82 91.94,92.82 92.07,92.7 92.07,84.19 94.61,81.65 94.61,74.71 95.13,74.19
VDD_5V0_LDO3 on BOTTOM: 103.75,33.9 103.75,31.18 108.07,31.18 108.07,32.75 105.41,32.75 105.15,33.01 105.15,33.9
VDD_5V0_LDO3 on BOTTOM: 10.02,59.3 10.02,61.71 12.19,61.71 12.19,59.3
VDD_5V0_LDO3 on L06_PWR2: 50.02,70.6 17.65,70.6 10.66,63.61 10.66,59.8 10.73,59.74 10.73,59.68 11.55,59.68 12.57,60.69 14.73,60.69 22.6,68.57 51.68,68.57 53.36,70.24 61.21,70.24 69.44,78.47 71.47,78.47 73.27,76.67 73.27,75.68 74.29,75.68 74.29,77.82 71.83,80.28 67.51,80.28 63.67,76.44 55.86,76.44
VDD_IO_3V3 on BOTTOM: 68.52,41.64 68.52,37.83 70.35,37.83 70.35,42.15 69.03,42.15
VDD_IO_3V3 on BOTTOM: 102.36,59.3 102.36,57.96 107.44,57.96 107.44,59.3
VDD_IO_3V3 on L06_PWR2: 50.54,44.56 50.54,38.85 53.59,35.8 53.59,35.67 55.37,35.67 55.62,35.93 55.62,37.07 54.99,37.71 54.99,40.25 56.13,41.39 56.26,41.39 56.26,44.82 57.02,45.58 57.4,45.58 58.29,44.69 58.29,44.56 58.67,44.18 63.75,44.18 64.26,44.69 65.4,44.69 65.91,44.18 65.91,43.29 64.51,41.9 64.51,38.34 65.78,37.07 65.78,36.94 65.4,36.56 65.4,34.28 65.53,34.15 78.35,34.15 82.29,38.09 93.59,38.09 106.93,51.42 106.93,58.66 106.17,59.42 101.98,59.42 92.83,50.28 56.26,50.28
VDD_MMC1 on TOP: 15.74,58.15 15.74,55.74 24.25,55.74 24.25,58.15
VDD_MMC1 on L05_PWR1: 20.95,57.26 20.95,50.41 24.63,50.41 24.63,57.26
VDDA1V8_OSC_PLL_F on L03_SIG1: 55.31,34.67 55.9,34.67 55.9,36.02 54.27,36.02 53.2,34.71 53.2,32.8 50.02,29.61 50.02,28.87 49.26,28.12 49.26,28.12 49.26,27.66 49.38,27.54 50.17,27.54 50.68,28.05 50.68,28.81 54.33,32.46 54.33,33.7
VDDA3V3_F on L06_PWR2: 57.4,37.2 57.4,35.67 59.28,35.67 59.28,35.35 59.59,35.04 59.59,32.08 60.57,31.1 70.35,31.1 71.37,32.12 71.37,32.88 71.02,33.23 70.32,33.23 69.08,31.99 63.07,31.99 62.04,33.02 62.04,36.56 61.4,37.2
VDDA_IO_1V8 on BOTTOM: 58.23,35.91 58.23,34.63 59.75,34.63 60.4,33.98 62.11,33.98 62.36,34.22 62.36,35.91
VDDA_IO_1V8 on L06_PWR2: 33.14,26.4 31.49,24.75 31.49,23.74 32,23.23 33.52,23.23 34.41,24.12 39.87,24.12 39.94,24.18 45.65,24.18 52.32,30.85 57.15,30.85 59.09,32.79 59.09,35.16 58.7,35.55 56.89,35.55 56.64,35.29 56.64,33.39 56.07,32.82 56,32.88 53.34,32.88 51.94,34.28 50.67,34.28 48.32,31.93 48.32,29.39 45.33,26.4
VDDA_IO_3V3 on L06_PWR2: 65.91,14.97 65.91,25.26 53.46,25.26 49.78,21.58 31.49,21.58 28.57,24.5 26.03,24.5 26.03,22.21 23.36,19.55 23.36,16.24 21.71,14.59 21.71,14.21 23.24,12.69 63.62,12.69
VDDIO on TOP: 69.46,97.27 69.46,95.75 72.77,95.75 72.77,97.27
VDDIO on TOP: 83.31,65.39 85.6,65.39 85.6,66.68 85.2,66.68 84.83,67.04 84.83,67.68 84.39,68.12 83.31,68.12
VDDIO on BOTTOM: 90.65,81.44 90.65,82.95 88.49,82.95 88.49,81.44
VDDIO on L06_PWR2: 68.96,97.27 68.96,91.68 74.67,85.97 74.67,61.96 95.37,61.96 95.5,61.84 99.18,61.84 99.69,61.33 99.69,59.55 99.82,59.42 100.71,59.42 100.83,59.55 100.83,69.96 97.79,73.01 95.5,73.01 93.98,74.54 93.98,80.51 91.44,83.05 91.44,91.3 91.05,91.68 76.32,91.68 72.77,95.24 72.77,97.14 72.64,97.27
VDDS_IO_1V8 on L06_PWR2: 55.88,37.45 55.88,35.55 55.24,34.91 54.48,34.91 53.97,35.42 44.57,35.42 41.65,32.5 41.65,30.72 42.03,30.34 42.67,30.34 42.92,30.59 42.92,31.74 44.51,33.32 48.27,33.32 49.86,34.91 52.57,34.91 53.97,33.52 55.62,33.52 56.19,34.09 56.19,35.36 56.89,36.06 56.89,37.2 57.53,37.83 61.72,37.83 62.46,37.09 62.46,33.42 63.64,32.25 68.58,32.25 69.08,32.75 69.08,33.64 68.96,33.77 67.31,33.77 67.18,33.9 65.15,33.9 64.64,34.4 64.64,36.06 65.15,36.56 65.15,37.07 64.13,38.09 64.13,42.02 65.27,43.17 65.27,44.18 65.15,44.31 64.64,44.31 64.13,43.8 58.42,43.8 57.15,45.07 56.89,45.07 56.64,44.82 56.64,41.26 55.37,39.99 55.37,37.96
(no net) on TOP: 17.42,2.35 17.42,7.1 13.83,7.1 14.63,7.85 14.93,8.9 14.93,13.3 10.02,13.3 10.02,76.95 10.27,76.7 34.79,76.7 37.97,73.52 45.08,73.52 45.46,73.9 45.46,96.63 44.83,97.27 41.65,97.27 41.27,97.65 41.27,108.36 113.74,108.36 113.74,7.1 112.15,7.1 112.15,2.65 88.9,2.65 88.9,13.3 70.35,13.3 70.35,8.88 70.64,7.84 71.43,7.1 67.88,7.1 67.88,2.53 67.87,2.55 43.25,2.55 43.25,5.2 41.04,7.42 38.82,5.2 38.82,2.35 ; 101 cut-outs
(no net) on BOTTOM: 17.42,2.35 17.42,7.1 13.83,7.1 14.63,7.85 14.93,8.9 14.93,13.3 10.02,13.3 10.02,76.95 10.27,76.7 34.79,76.7 37.97,73.52 45.08,73.52 45.46,73.9 45.46,96.63 44.83,97.27 41.65,97.27 41.27,97.65 41.27,108.19 113.74,108.19 113.74,7.1 112.15,7.1 112.15,2.65 88.9,2.65 88.9,13.3 70.35,13.3 70.35,8.88 70.64,7.84 71.43,7.1 67.88,7.1 67.88,2.53 67.87,2.55 43.25,2.55 43.25,5.2 41.04,7.42 38.82,5.2 38.82,2.35 ; 127 cut-outs
